F** Generated for: hspiceD
** Generated on: Dec  5 21:12:19 2024
** Design library name: final_project
** Design cell name: ImageComparator
** Design view name: av_extracted

.TEMP 25.0
.OPTION
+    ARTIST=2
+    INGOLD=2
+    PARHIER=LOCAL
+    PSF=2

** Library name: final_project
** Cell name: ImageComparator
** View name: av_extracted
c1 vdd vss 35.3896e-18
c2 clk_out vss 6.57109e-18
c3 clk4 vss 9.44781e-18
c4 chipdriverout vss 60.3007e-18
c5 r0 vss 17.6823e-18
c6 r1 vss 26.6102e-18
c7 r2 vss 19.3651e-18
c8 _net0 vss 232.437e-18
c9 vddio vss 3.69481e-21
c10 pinout vss 89.1513e-18
c11 pinin vss 24.4453e-18
c12 s vss 22.4013e-18
c13 i3__net13 vss 23.594e-18
c14 i3__net9 vss 22.779e-18
c15 i3__net10 vss 20.5706e-18
c16 i3__net11 vss 22.6343e-18
c17 i3__net12 vss 20.2109e-18
c18 i3__i1__net5 vss 54.7052e-18
c19 i3__i1__net3 vss 66.4736e-18
c20 i3__i1__net2 vss 25.195e-18
c21 i3__i1__net1 vss 54.3633e-18
c22 i3__i1__net4 vss 67.688e-18
c23 i3__i0__net5 vss 55.1641e-18
c24 i3__i0__net3 vss 66.6245e-18
c25 i3__i0__net2 vss 25.2389e-18
c26 i3__i0__net1 vss 53.5074e-18
c27 i3__i0__net4 vss 67.8697e-18
c28 i3__i6__net2 vss 93.3673e-18
c29 i3__i6__net1 vss 24.6291e-18
c30 i1__net3 vss 21.6832e-18
c31 i1__net4 vss 117.602e-18
c32 i1__net5 vss 22.4044e-18
c33 i1__net6 vss 115.582e-18
c34 i1__net7 vss 21.8597e-18
c35 i1__net1 vss 20.1765e-18
c36 i1__i3__net25 vss 54.6928e-18
c37 i1__i3__net24 vss 68.3643e-18
c38 i1__i3__net22 vss 26.2992e-18
c39 i1__i3__net23 vss 54.4567e-18
c40 i1__i3__net21 vss 69.7289e-18
c41 i1__i2__net25 vss 54.4368e-18
c42 i1__i2__net24 vss 69.4759e-18
c43 i1__i2__net22 vss 25.3366e-18
c44 i1__i2__net23 vss 54.5e-18
c45 i1__i2__net21 vss 69.1265e-18
c46 i1__i1__net25 vss 54.8588e-18
c47 i1__i1__net24 vss 69.4543e-18
c48 i1__i1__net22 vss 25.262e-18
c49 i1__i1__net23 vss 55.1789e-18
c50 i1__i1__net21 vss 69.3305e-18
c51 i1__i11__net4 vss 20.4804e-18
c52 i1__i10__net4 vss 19.719e-18
c53 i1__i9__net4 vss 19.9314e-18
c54 i0__net4 vss 46.2343e-18
c55 i0__net3 vss 120.588e-18
c56 i0__net2 vss 21.308e-18
c57 i0__i14__net1 vss 255.398e-18
c58 i0__i11__outinv vss 32.0604e-18
c59 i0__i13__net1 vss 188.892e-18
c60 i0__i12__net1 vss 46.4294e-18
c61 n4__i0__i11__outinv vss 36.7605e-18
c62 n2__i0__i11__outinv vss 37.5565e-18
c63 n12__i0__net4 vss 38.1791e-18
c64 n10__i0__net4 vss 40.5349e-18
c65 n7__i0__net4 vss 71.8792e-18
c66 n3__i0__net4 vss 61.3655e-18
c67 n27__i0__i12__net1 vss 69.4621e-18
c68 n23__i0__i12__net1 vss 56.389e-18
c69 n19__i0__i12__net1 vss 52.6796e-18
c70 n15__i0__i12__net1 vss 58.1686e-18
c71 n11__i0__i12__net1 vss 59.0736e-18
c72 n7__i0__i12__net1 vss 60.4996e-18
c73 n3__i0__i12__net1 vss 61.5801e-18
c74 n23__i0__net3 vss 189.95e-18
c75 n19__i0__net3 vss 157.013e-18
c76 n15__i0__net3 vss 159.479e-18
c77 n11__i0__net3 vss 159.365e-18
c78 n7__i0__net3 vss 161.955e-18
c79 n3__i0__net3 vss 166.102e-18
c80 n121__i0__i13__net1 vss 171.544e-18
c81 n99__i0__i13__net1 vss 161.576e-18
c82 n93__i0__i13__net1 vss 161.83e-18
c83 n81__i0__i13__net1 vss 162.43e-18
c84 n77__i0__i13__net1 vss 166.919e-18
c85 n65__i0__i13__net1 vss 165.122e-18
c86 n61__i0__i13__net1 vss 166.204e-18
c87 n53__i0__i13__net1 vss 163.509e-18
c88 n49__i0__i13__net1 vss 162.849e-18
c89 n45__i0__i13__net1 vss 160.991e-18
c90 n41__i0__i13__net1 vss 161.212e-18
c91 n37__i0__i13__net1 vss 162.77e-18
c92 n33__i0__i13__net1 vss 167.432e-18
c93 n29__i0__i13__net1 vss 163.587e-18
c94 n25__i0__i13__net1 vss 162.841e-18
c95 n21__i0__i13__net1 vss 161.022e-18
c96 n17__i0__i13__net1 vss 161.515e-18
c97 n13__i0__i13__net1 vss 164.243e-18
c98 n9__i0__i13__net1 vss 165.494e-18
c99 n5__i0__i13__net1 vss 161.027e-18
c100 n179__i0__net2 vss 357.551e-18
c101 n155__i0__net2 vss 325.841e-18
c102 n151__i0__net2 vss 385.273e-18
c103 n139__i0__net2 vss 334.089e-18
c104 n135__i0__net2 vss 384.178e-18
c105 n123__i0__net2 vss 329.218e-18
c106 n119__i0__net2 vss 385.099e-18
c107 n107__i0__net2 vss 319.356e-18
c108 n103__i0__net2 vss 385.286e-18
c109 n95__i0__net2 vss 324.658e-18
c110 n87__i0__net2 vss 385.493e-18
c111 n75__i0__net2 vss 334.071e-18
c112 n71__i0__net2 vss 385.58e-18
c113 n59__i0__net2 vss 329.418e-18
c114 n55__i0__net2 vss 385.173e-18
c115 n51__i0__net2 vss 335.557e-18
c116 n47__i0__net2 vss 343.814e-18
c117 n43__i0__net2 vss 380.51e-18
c118 n39__i0__net2 vss 334.098e-18
c119 n35__i0__net2 vss 380.273e-18
c120 n31__i0__net2 vss 328.043e-18
c121 n27__i0__net2 vss 393.506e-18
c122 n23__i0__net2 vss 337.025e-18
c123 n19__i0__net2 vss 393.797e-18
c124 n15__i0__net2 vss 342.072e-18
c125 n12__i0__net2 vss 380.381e-18
c126 n7__i0__net2 vss 334.732e-18
c127 n4__i0__net2 vss 320.445e-18
c128 n715__i0__i14__net1 vss 410.126e-18
c129 n707__i0__i14__net1 vss 329.646e-18
c130 n703__i0__i14__net1 vss 384.463e-18
c131 n691__i0__i14__net1 vss 378.265e-18
c132 n687__i0__i14__net1 vss 368.056e-18
c133 n675__i0__i14__net1 vss 373.659e-18
c134 n671__i0__i14__net1 vss 370.408e-18
c135 n659__i0__i14__net1 vss 329.686e-18
c136 n655__i0__i14__net1 vss 384.997e-18
c137 n647__i0__i14__net1 vss 328.915e-18
c138 n635__i0__i14__net1 vss 384.592e-18
c139 n627__i0__i14__net1 vss 374.033e-18
c140 n619__i0__i14__net1 vss 368.387e-18
c141 n611__i0__i14__net1 vss 378.379e-18
c142 n603__i0__i14__net1 vss 369.379e-18
c143 n595__i0__i14__net1 vss 379.178e-18
c144 n591__i0__i14__net1 vss 378.353e-18
c145 n579__i0__i14__net1 vss 361.859e-18
c146 n575__i0__i14__net1 vss 382.949e-18
c147 n563__i0__i14__net1 vss 362.204e-18
c148 n559__i0__i14__net1 vss 335.474e-18
c149 n547__i0__i14__net1 vss 380.406e-18
c150 n543__i0__i14__net1 vss 334.64e-18
c151 n531__i0__i14__net1 vss 360.74e-18
c152 n523__i0__i14__net1 vss 357.107e-18
c153 n515__i0__i14__net1 vss 361.468e-18
c154 n507__i0__i14__net1 vss 383.228e-18
c155 n499__i0__i14__net1 vss 366.225e-18
c156 n491__i0__i14__net1 vss 335.524e-18
c157 n483__i0__i14__net1 vss 384.026e-18
c158 n479__i0__i14__net1 vss 384.123e-18
c159 n467__i0__i14__net1 vss 369.482e-18
c160 n463__i0__i14__net1 vss 378.412e-18
c161 n451__i0__i14__net1 vss 384.7e-18
c162 n447__i0__i14__net1 vss 337.136e-18
c163 n435__i0__i14__net1 vss 393.753e-18
c164 n431__i0__i14__net1 vss 341.906e-18
c165 n424__i0__i14__net1 vss 380.412e-18
c166 n411__i0__i14__net1 vss 383.862e-18
c167 n408__i0__i14__net1 vss 365.177e-18
c168 n395__i0__i14__net1 vss 378.5e-18
c169 n392__i0__i14__net1 vss 384.795e-18
c170 n379__i0__i14__net1 vss 337.332e-18
c171 n376__i0__i14__net1 vss 393.721e-18
c172 n363__i0__i14__net1 vss 337.26e-18
c173 n360__i0__i14__net1 vss 381.653e-18
c174 n347__i0__i14__net1 vss 384.582e-18
c175 n344__i0__i14__net1 vss 328.868e-18
c176 n331__i0__i14__net1 vss 385.435e-18
c177 n328__i0__i14__net1 vss 328.218e-18
c178 n315__i0__i14__net1 vss 371.192e-18
c179 n312__i0__i14__net1 vss 372.235e-18
c180 n299__i0__i14__net1 vss 370.09e-18
c181 n295__i0__i14__net1 vss 376.442e-18
c182 n287__i0__i14__net1 vss 384.735e-18
c183 n279__i0__i14__net1 vss 326.891e-18
c184 n271__i0__i14__net1 vss 385.508e-18
c185 n259__i0__i14__net1 vss 327.881e-18
c186 n255__i0__i14__net1 vss 385.28e-18
c187 n243__i0__i14__net1 vss 322.73e-18
c188 n239__i0__i14__net1 vss 384.016e-18
c189 n227__i0__i14__net1 vss 338.809e-18
c190 n223__i0__i14__net1 vss 385.805e-18
c191 n211__i0__i14__net1 vss 329.049e-18
c192 n207__i0__i14__net1 vss 383.533e-18
c193 n199__i0__i14__net1 vss 319.222e-18
c194 n191__i0__i14__net1 vss 384.913e-18
c195 n179__i0__i14__net1 vss 325.114e-18
c196 n175__i0__i14__net1 vss 384.976e-18
c197 n163__i0__i14__net1 vss 334.063e-18
c198 n159__i0__i14__net1 vss 385.576e-18
c199 n147__i0__i14__net1 vss 329.054e-18
c200 n143__i0__i14__net1 vss 383.407e-18
c201 n131__i0__i14__net1 vss 331.998e-18
c202 n127__i0__i14__net1 vss 341.986e-18
c203 n115__i0__i14__net1 vss 385.74e-18
c204 n111__i0__i14__net1 vss 333.566e-18
c205 n99__i0__i14__net1 vss 376.682e-18
c206 n95__i0__i14__net1 vss 324.982e-18
c207 n83__i0__i14__net1 vss 381.547e-18
c208 n79__i0__i14__net1 vss 334.21e-18
c209 n68__i0__i14__net1 vss 381.487e-18
c210 n59__i0__i14__net1 vss 343.065e-18
c211 n56__i0__i14__net1 vss 377.007e-18
c212 n51__i0__i14__net1 vss 334.227e-18
c213 n48__i0__i14__net1 vss 377.021e-18
c214 n43__i0__i14__net1 vss 324.901e-18
c215 n40__i0__i14__net1 vss 384.836e-18
c216 n35__i0__i14__net1 vss 366.217e-18
c217 n32__i0__i14__net1 vss 378.676e-18
c218 n27__i0__i14__net1 vss 384.867e-18
c219 n24__i0__i14__net1 vss 328.549e-18
c220 n19__i0__i14__net1 vss 385.491e-18
c221 n15__i0__i14__net1 vss 328.51e-18
c222 n11__i0__i14__net1 vss 385.075e-18
c223 n7__i0__i14__net1 vss 328.119e-18
c224 n3__i0__i14__net1 vss 397.767e-18
c225 n9__pinin vss 17.1436e-18
c226 n11__pinin vss 16.6003e-18
c227 n13__pinin vss 20.3359e-18
c228 n21__i1__net1 vss 24.6648e-18
c229 n31__clk vss 23.2116e-18
c230 n30__s vss 20.3039e-18
c231 n20__s vss 23.6131e-18
c232 n14__i1__net1 vss 26.216e-18
c233 n24__clk vss 23.2116e-18
c234 n11__i3__net13 vss 59.8192e-18
c235 n4__clk4 vss 40.0135e-18
c236 n1__clk4 vss 25.0569e-18
c237 n18__s vss 20.4748e-18
c238 n3__i3__net12 vss 23.7876e-18
c239 n8__s vss 24.0107e-18
c240 n7__i3__net13 vss 22.3404e-18
c241 n3__i1__net1 vss 26.8831e-18
c242 n4__i3__net13 vss 22.6904e-18
c243 n11__clk vss 23.2981e-18
c244 n3__i3__net10 vss 24.9052e-18
c245 n6__s vss 20.6066e-18
c246 n7__clk vss 22.3395e-18
c247 n1__clk vss 28.1608e-18
c248 n4__clk vss 26.5945e-18
c249 n14__pinout vss 52.326e-18
c250 n12__pinout vss 46.0578e-18
c251 n10__pinout vss 46.0094e-18
c252 n29__pinin vss 47.4313e-18
c253 n27__pinin vss 54.6933e-18
c254 n25__pinin vss 48.9213e-18
c255 n5__i0__net4 vss 49.6132e-18
c256 n25__i0__i12__net1 vss 45.8877e-18
c257 n21__i0__i12__net1 vss 41.791e-18
c258 n17__i0__i12__net1 vss 40.2269e-18
c259 n13__i0__i12__net1 vss 43.3243e-18
c260 n9__i0__i12__net1 vss 43.5937e-18
c261 n5__i0__i12__net1 vss 40.4305e-18
c262 n21__i0__net3 vss 134.697e-18
c263 n17__i0__net3 vss 111.963e-18
c264 n13__i0__net3 vss 115.611e-18
c265 n9__i0__net3 vss 115.85e-18
c266 n5__i0__net3 vss 116.36e-18
c267 n124__i0__i13__net1 vss 115.398e-18
c268 n101__i0__i13__net1 vss 109.807e-18
c269 n96__i0__i13__net1 vss 109.89e-18
c270 n83__i0__i13__net1 vss 111.344e-18
c271 n80__i0__i13__net1 vss 109.41e-18
c272 n67__i0__i13__net1 vss 108.594e-18
c273 n64__i0__i13__net1 vss 118.284e-18
c274 n55__i0__i13__net1 vss 117.155e-18
c275 n52__i0__i13__net1 vss 115.458e-18
c276 n47__i0__i13__net1 vss 116.76e-18
c277 n44__i0__i13__net1 vss 117.014e-18
c278 n39__i0__i13__net1 vss 115.678e-18
c279 n36__i0__i13__net1 vss 114.066e-18
c280 n31__i0__i13__net1 vss 116.968e-18
c281 n28__i0__i13__net1 vss 115.445e-18
c282 n23__i0__i13__net1 vss 116.715e-18
c283 n19__i0__i13__net1 vss 116.036e-18
c284 n15__i0__i13__net1 vss 113.582e-18
c285 n11__i0__i13__net1 vss 118.816e-18
c286 n7__i0__i13__net1 vss 116.687e-18
c287 n3__i0__i13__net1 vss 121.573e-18
c288 n177__i0__net2 vss 263.503e-18
c289 n153__i0__net2 vss 220.655e-18
c290 n149__i0__net2 vss 261.514e-18
c291 n137__i0__net2 vss 220.229e-18
c292 n133__i0__net2 vss 260.843e-18
c293 n121__i0__net2 vss 220.114e-18
c294 n117__i0__net2 vss 261.416e-18
c295 n105__i0__net2 vss 220.104e-18
c296 n101__i0__net2 vss 261.636e-18
c297 n93__i0__net2 vss 219.565e-18
c298 n85__i0__net2 vss 261.79e-18
c299 n73__i0__net2 vss 220.117e-18
c300 n69__i0__net2 vss 261.696e-18
c301 n57__i0__net2 vss 220.167e-18
c302 n53__i0__net2 vss 262.027e-18
c303 n49__i0__net2 vss 232.737e-18
c304 n45__i0__net2 vss 264.479e-18
c305 n41__i0__net2 vss 221.43e-18
c306 n37__i0__net2 vss 264.184e-18
c307 n33__i0__net2 vss 221.231e-18
c308 n29__i0__net2 vss 263.658e-18
c309 n25__i0__net2 vss 221.117e-18
c310 n21__i0__net2 vss 264.159e-18
c311 n17__i0__net2 vss 221.164e-18
c312 n13__i0__net2 vss 264.117e-18
c313 n10__i0__net2 vss 221.17e-18
c314 n5__i0__net2 vss 264.715e-18
c315 n2__i0__net2 vss 245.281e-18
c316 n713__i0__i14__net1 vss 244.453e-18
c317 n705__i0__i14__net1 vss 219.347e-18
c318 n701__i0__i14__net1 vss 260.759e-18
c319 n689__i0__i14__net1 vss 223.945e-18
c320 n685__i0__i14__net1 vss 259.169e-18
c321 n673__i0__i14__net1 vss 221.48e-18
c322 n669__i0__i14__net1 vss 262.829e-18
c323 n657__i0__i14__net1 vss 215.952e-18
c324 n653__i0__i14__net1 vss 260.382e-18
c325 n645__i0__i14__net1 vss 217.995e-18
c326 n633__i0__i14__net1 vss 260.446e-18
c327 n625__i0__i14__net1 vss 221.237e-18
c328 n617__i0__i14__net1 vss 262.278e-18
c329 n609__i0__i14__net1 vss 218.664e-18
c330 n601__i0__i14__net1 vss 263.065e-18
c331 n593__i0__i14__net1 vss 226.238e-18
c332 n589__i0__i14__net1 vss 262.565e-18
c333 n577__i0__i14__net1 vss 220.103e-18
c334 n573__i0__i14__net1 vss 262.27e-18
c335 n561__i0__i14__net1 vss 219.765e-18
c336 n557__i0__i14__net1 vss 261.881e-18
c337 n545__i0__i14__net1 vss 219.865e-18
c338 n541__i0__i14__net1 vss 262.179e-18
c339 n529__i0__i14__net1 vss 210.547e-18
c340 n521__i0__i14__net1 vss 249.824e-18
c341 n513__i0__i14__net1 vss 219.761e-18
c342 n505__i0__i14__net1 vss 262.539e-18
c343 n497__i0__i14__net1 vss 220.276e-18
c344 n489__i0__i14__net1 vss 232.938e-18
c345 n481__i0__i14__net1 vss 254.989e-18
c346 n477__i0__i14__net1 vss 223.858e-18
c347 n465__i0__i14__net1 vss 259.917e-18
c348 n461__i0__i14__net1 vss 225.115e-18
c349 n449__i0__i14__net1 vss 256.289e-18
c350 n445__i0__i14__net1 vss 224.429e-18
c351 n433__i0__i14__net1 vss 255.681e-18
c352 n429__i0__i14__net1 vss 224.892e-18
c353 n422__i0__i14__net1 vss 255.211e-18
c354 n409__i0__i14__net1 vss 223.71e-18
c355 n406__i0__i14__net1 vss 259.496e-18
c356 n393__i0__i14__net1 vss 223.961e-18
c357 n390__i0__i14__net1 vss 260.871e-18
c358 n377__i0__i14__net1 vss 224.674e-18
c359 n374__i0__i14__net1 vss 255.17e-18
c360 n361__i0__i14__net1 vss 256.485e-18
c361 n358__i0__i14__net1 vss 250.21e-18
c362 n345__i0__i14__net1 vss 254.995e-18
c363 n342__i0__i14__net1 vss 253.137e-18
c364 n329__i0__i14__net1 vss 255.325e-18
c365 n326__i0__i14__net1 vss 254.673e-18
c366 n313__i0__i14__net1 vss 254.954e-18
c367 n310__i0__i14__net1 vss 255.186e-18
c368 n297__i0__i14__net1 vss 254.547e-18
c369 n293__i0__i14__net1 vss 250.838e-18
c370 n285__i0__i14__net1 vss 255.419e-18
c371 n277__i0__i14__net1 vss 250.036e-18
c372 n269__i0__i14__net1 vss 255.965e-18
c373 n257__i0__i14__net1 vss 219.822e-18
c374 n253__i0__i14__net1 vss 222.285e-18
c375 n241__i0__i14__net1 vss 252.969e-18
c376 n237__i0__i14__net1 vss 250.032e-18
c377 n225__i0__i14__net1 vss 252.68e-18
c378 n221__i0__i14__net1 vss 261.27e-18
c379 n209__i0__i14__net1 vss 222.026e-18
c380 n205__i0__i14__net1 vss 252.915e-18
c381 n197__i0__i14__net1 vss 253.742e-18
c382 n189__i0__i14__net1 vss 252.804e-18
c383 n177__i0__i14__net1 vss 253.797e-18
c384 n173__i0__i14__net1 vss 252.693e-18
c385 n161__i0__i14__net1 vss 253.67e-18
c386 n157__i0__i14__net1 vss 253.159e-18
c387 n145__i0__i14__net1 vss 253.917e-18
c388 n141__i0__i14__net1 vss 252.223e-18
c389 n129__i0__i14__net1 vss 246.014e-18
c390 n125__i0__i14__net1 vss 257.953e-18
c391 n113__i0__i14__net1 vss 224.887e-18
c392 n109__i0__i14__net1 vss 261.07e-18
c393 n97__i0__i14__net1 vss 218.599e-18
c394 n93__i0__i14__net1 vss 261.798e-18
c395 n81__i0__i14__net1 vss 218.891e-18
c396 n77__i0__i14__net1 vss 260.859e-18
c397 n66__i0__i14__net1 vss 219.222e-18
c398 n57__i0__i14__net1 vss 261.902e-18
c399 n54__i0__i14__net1 vss 219.213e-18
c400 n49__i0__i14__net1 vss 261.898e-18
c401 n46__i0__i14__net1 vss 219.277e-18
c402 n41__i0__i14__net1 vss 257.741e-18
c403 n38__i0__i14__net1 vss 256.778e-18
c404 n33__i0__i14__net1 vss 219.758e-18
c405 n30__i0__i14__net1 vss 262.364e-18
c406 n25__i0__i14__net1 vss 227.036e-18
c407 n22__i0__i14__net1 vss 257.526e-18
c408 n17__i0__i14__net1 vss 226.382e-18
c409 n13__i0__i14__net1 vss 257.876e-18
c410 n9__i0__i14__net1 vss 226.073e-18
c411 n5__i0__i14__net1 vss 257.843e-18
c412 n7__pinin vss 23.8071e-18
c413 n8__pinin vss 13.8671e-18
c414 n10__pinin vss 12.9555e-18
c415 n12__pinin vss 16.0855e-18
c416 n11__reset vss 42.3675e-18
c417 n36__clk vss 20.5578e-18
c418 n4__i1__i3__net22 vss 29.029e-18
c419 n16__i1__net1 vss 20.2564e-18
c420 n4__i1__net7 vss 24.1076e-18
c421 n3__i1__i11__net4 vss 19.6622e-18
c422 n28__s vss 17.0379e-18
c423 n22__s vss 17.7824e-18
c424 n6__reset vss 42.346e-18
c425 n29__clk vss 20.5134e-18
c426 n4__i1__i2__net22 vss 28.8754e-18
c427 n3__i3__i6__net1 vss 20.5697e-18
c428 n9__i1__net1 vss 20.1765e-18
c429 n12__i3__net13 vss 31.8577e-18
c430 n4__i1__net5 vss 26.6687e-18
c431 n7__clk4 vss 28.3352e-18
c432 n3__clk4 vss 15.3703e-18
c433 n3__i1__i10__net4 vss 19.3349e-18
c434 n16__s vss 16.3788e-18
c435 n9__i3__net13 vss 21.3228e-18
c436 n10__s vss 17.5308e-18
c437 n4__i3__i1__net2 vss 25.7494e-18
c438 n1__reset vss 41.2665e-18
c439 n4__i3__net11 vss 28.1772e-18
c440 n13__clk vss 20.5134e-18
c441 n4__i1__i1__net22 vss 29.0153e-18
c442 n6__i3__net13 vss 21.7663e-18
c443 n3__i3__net13 vss 19.6511e-18
c444 n4__i1__net3 vss 26.8456e-18
c445 n9__clk vss 21.3088e-18
c446 n4__i3__i0__net2 vss 26.8563e-18
c447 n3__i1__i9__net4 vss 19.539e-18
c448 n4__s vss 16.4516e-18
c449 n4__i3__net9 vss 26.7493e-18
c450 n3__s vss 22.6419e-18
c451 n3__clk vss 26.8967e-18
c452 n6__clk vss 21.2453e-18
c453 n13__pinout vss 21.6805e-18
c454 n3__i0__i11__outinv vss 23.0928e-18
c455 n11__pinout vss 14.5236e-18
c456 n9__pinout vss 20.7625e-18
c457 n11__i0__net4 vss 27.2869e-18
c458 n28__pinin vss 17.0977e-18
c459 n9__i0__net4 vss 25.1402e-18
c460 n24__pinin vss 24.9113e-18
c461 n6__i0__net4 vss 17.0736e-18
c462 n8__i0__net4 vss 18.3607e-18
c463 n2__i0__net4 vss 27.2306e-18
c464 n4__i0__net4 vss 25.2534e-18
c465 n26__i0__i12__net1 vss 79.2661e-18
c466 n28__i0__i12__net1 vss 64.1675e-18
c467 n22__i0__i12__net1 vss 16.2233e-18
c468 n24__i0__i12__net1 vss 16.1035e-18
c469 n18__i0__i12__net1 vss 16.2148e-18
c470 n20__i0__i12__net1 vss 16.1167e-18
c471 n14__i0__i12__net1 vss 16.2234e-18
c472 n16__i0__i12__net1 vss 16.1252e-18
c473 n10__i0__i12__net1 vss 16.2257e-18
c474 n12__i0__i12__net1 vss 16.1258e-18
c475 n6__i0__i12__net1 vss 16.3449e-18
c476 n8__i0__i12__net1 vss 16.8925e-18
c477 n2__i0__i12__net1 vss 27.8868e-18
c478 n4__i0__i12__net1 vss 26.6684e-18
c479 n22__i0__net3 vss 26.5288e-18
c480 n24__i0__net3 vss 26.5946e-18
c481 n18__i0__net3 vss 15.688e-18
c482 n20__i0__net3 vss 15.6869e-18
c483 n14__i0__net3 vss 76.8592e-18
c484 n16__i0__net3 vss 54.5002e-18
c485 n10__i0__net3 vss 15.5656e-18
c486 n12__i0__net3 vss 15.5607e-18
c487 n6__i0__net3 vss 15.6415e-18
c488 n8__i0__net3 vss 15.5602e-18
c489 n2__i0__net3 vss 22.8853e-18
c490 n4__i0__net3 vss 23.4989e-18
c491 n123__i0__i13__net1 vss 23.3747e-18
c492 n122__i0__i13__net1 vss 22.7493e-18
c493 n102__i0__i13__net1 vss 15.5433e-18
c494 n100__i0__i13__net1 vss 15.2882e-18
c495 n95__i0__i13__net1 vss 15.1475e-18
c496 n94__i0__i13__net1 vss 15.098e-18
c497 n84__i0__i13__net1 vss 15.5433e-18
c498 n82__i0__i13__net1 vss 15.2882e-18
c499 n79__i0__i13__net1 vss 15.1475e-18
c500 n78__i0__i13__net1 vss 15.098e-18
c501 n68__i0__i13__net1 vss 80.1353e-18
c502 n66__i0__i13__net1 vss 51.6221e-18
c503 n63__i0__i13__net1 vss 15.1475e-18
c504 n62__i0__i13__net1 vss 15.098e-18
c505 n56__i0__i13__net1 vss 15.5433e-18
c506 n54__i0__i13__net1 vss 15.2882e-18
c507 n51__i0__i13__net1 vss 15.1475e-18
c508 n50__i0__i13__net1 vss 15.098e-18
c509 n48__i0__i13__net1 vss 15.5433e-18
c510 n46__i0__i13__net1 vss 15.2882e-18
c511 n43__i0__i13__net1 vss 15.1475e-18
c512 n42__i0__i13__net1 vss 15.098e-18
c513 n40__i0__i13__net1 vss 15.5433e-18
c514 n38__i0__i13__net1 vss 15.2882e-18
c515 n35__i0__i13__net1 vss 15.1475e-18
c516 n34__i0__i13__net1 vss 15.098e-18
c517 n32__i0__i13__net1 vss 79.6297e-18
c518 n30__i0__i13__net1 vss 51.5042e-18
c519 n27__i0__i13__net1 vss 79.8701e-18
c520 n26__i0__i13__net1 vss 50.3104e-18
c521 n24__i0__i13__net1 vss 15.72e-18
c522 n22__i0__i13__net1 vss 15.4514e-18
c523 n20__i0__i13__net1 vss 15.3317e-18
c524 n18__i0__i13__net1 vss 15.6304e-18
c525 n16__i0__i13__net1 vss 15.3681e-18
c526 n14__i0__i13__net1 vss 15.4899e-18
c527 n12__i0__i13__net1 vss 15.1678e-18
c528 n10__i0__i13__net1 vss 15.48e-18
c529 n8__i0__i13__net1 vss 15.3681e-18
c530 n6__i0__i13__net1 vss 15.527e-18
c531 n4__i0__i13__net1 vss 15.0611e-18
c532 n2__i0__i13__net1 vss 23.8043e-18
c533 n178__i0__net2 vss 66.5114e-18
c534 n180__i0__net2 vss 64.4052e-18
c535 n154__i0__net2 vss 14.5676e-18
c536 n156__i0__net2 vss 14.65e-18
c537 n150__i0__net2 vss 14.5528e-18
c538 n152__i0__net2 vss 14.65e-18
c539 n138__i0__net2 vss 14.5528e-18
c540 n140__i0__net2 vss 14.65e-18
c541 n134__i0__net2 vss 14.5528e-18
c542 n136__i0__net2 vss 14.65e-18
c543 n122__i0__net2 vss 14.5528e-18
c544 n124__i0__net2 vss 14.65e-18
c545 n118__i0__net2 vss 53.9493e-18
c546 n120__i0__net2 vss 62.651e-18
c547 n106__i0__net2 vss 14.4652e-18
c548 n108__i0__net2 vss 14.5621e-18
c549 n102__i0__net2 vss 14.2762e-18
c550 n104__i0__net2 vss 14.3732e-18
c551 n94__i0__net2 vss 14.1653e-18
c552 n96__i0__net2 vss 14.2625e-18
c553 n86__i0__net2 vss 14.351e-18
c554 n88__i0__net2 vss 14.4483e-18
c555 n74__i0__net2 vss 14.1653e-18
c556 n76__i0__net2 vss 14.2625e-18
c557 n70__i0__net2 vss 14.351e-18
c558 n72__i0__net2 vss 14.4483e-18
c559 n58__i0__net2 vss 14.1653e-18
c560 n60__i0__net2 vss 14.2625e-18
c561 n54__i0__net2 vss 53.7239e-18
c562 n56__i0__net2 vss 62.274e-18
c563 n50__i0__net2 vss 14.1653e-18
c564 n52__i0__net2 vss 14.2625e-18
c565 n46__i0__net2 vss 14.351e-18
c566 n48__i0__net2 vss 14.4483e-18
c567 n42__i0__net2 vss 14.1653e-18
c568 n44__i0__net2 vss 14.2625e-18
c569 n38__i0__net2 vss 14.351e-18
c570 n40__i0__net2 vss 14.4483e-18
c571 n34__i0__net2 vss 14.1653e-18
c572 n36__i0__net2 vss 14.2625e-18
c573 n30__i0__net2 vss 14.351e-18
c574 n32__i0__net2 vss 14.4483e-18
c575 n26__i0__net2 vss 14.1653e-18
c576 n28__i0__net2 vss 14.2625e-18
c577 n22__i0__net2 vss 14.351e-18
c578 n24__i0__net2 vss 14.4483e-18
c579 n18__i0__net2 vss 50.0732e-18
c580 n20__i0__net2 vss 62.1811e-18
c581 n6__pinin vss 25.9156e-18
c582 n14__i0__net2 vss 14.2634e-18
c583 n16__i0__net2 vss 14.3604e-18
c584 n9__i0__net2 vss 14.1377e-18
c585 n11__i0__net2 vss 14.2349e-18
c586 n12__reset vss 60.013e-18
c587 n6__i0__net2 vss 14.5322e-18
c588 n8__i0__net2 vss 14.6442e-18
c589 n3__i0__net2 vss 21.7047e-18
c590 n22__i1__net1 vss 80.0606e-18
c591 n37__clk vss 70.5183e-18
c592 n3__i1__i3__net22 vss 40.6662e-18
c593 n32__clk vss 81.2892e-18
c594 n17__i1__net1 vss 71.858e-18
c595 n3__i1__net7 vss 9.25132e-18
c596 n31__s vss 205.891e-18
c597 n4__i1__i11__net4 vss 225.507e-18
c598 n714__i0__i14__net1 vss 67.6842e-18
c599 n716__i0__i14__net1 vss 75.5763e-18
c600 n706__i0__i14__net1 vss 14.4747e-18
c601 n708__i0__i14__net1 vss 14.3542e-18
c602 n2__i1__i11__net4 vss 86.3915e-18
c603 n29__s vss 233.183e-18
c604 n702__i0__i14__net1 vss 61.1405e-18
c605 n704__i0__i14__net1 vss 53.1261e-18
c606 n690__i0__i14__net1 vss 58.3447e-18
c607 n692__i0__i14__net1 vss 53.0038e-18
c608 n21__s vss 25.7659e-18
c609 n686__i0__i14__net1 vss 14.2593e-18
c610 n688__i0__i14__net1 vss 14.1434e-18
c611 n7__reset vss 58.0572e-18
c612 n674__i0__i14__net1 vss 14.4451e-18
c613 n676__i0__i14__net1 vss 14.9876e-18
c614 n670__i0__i14__net1 vss 61.3785e-18
c615 n672__i0__i14__net1 vss 48.6317e-18
c616 n15__i1__net1 vss 81.6411e-18
c617 n30__clk vss 71.586e-18
c618 n658__i0__i14__net1 vss 14.3702e-18
c619 n660__i0__i14__net1 vss 14.9125e-18
c620 n654__i0__i14__net1 vss 61.3288e-18
c621 n656__i0__i14__net1 vss 53.3691e-18
c622 n3__i1__i2__net22 vss 42.321e-18
c623 n646__i0__i14__net1 vss 14.6468e-18
c624 n648__i0__i14__net1 vss 14.5246e-18
c625 n2__i3__i6__net1 vss 79.7228e-18
c626 n25__clk vss 81.6378e-18
c627 n10__i1__net1 vss 72.4274e-18
c628 n634__i0__i14__net1 vss 14.6468e-18
c629 n636__i0__i14__net1 vss 14.5246e-18
c630 n626__i0__i14__net1 vss 14.6468e-18
c631 n628__i0__i14__net1 vss 14.5246e-18
c632 n13__i3__net13 vss 29.8793e-18
c633 n3__i1__net5 vss 8.44265e-18
c634 n6__clk4 vss 9.63044e-18
c635 n618__i0__i14__net1 vss 14.6468e-18
c636 n620__i0__i14__net1 vss 14.5246e-18
c637 n610__i0__i14__net1 vss 14.6468e-18
c638 n612__i0__i14__net1 vss 15.158e-18
c639 n2__clk4 vss 75.1294e-18
c640 n19__s vss 205.422e-18
c641 n4__i1__i10__net4 vss 222.08e-18
c642 n602__i0__i14__net1 vss 14.6468e-18
c643 n604__i0__i14__net1 vss 14.5246e-18
c644 n594__i0__i14__net1 vss 14.6468e-18
c645 n596__i0__i14__net1 vss 15.158e-18
c646 n2__i1__i10__net4 vss 87.1608e-18
c647 n17__s vss 233.641e-18
c648 n4__i3__net12 vss 81.3616e-18
c649 n10__i3__net13 vss 19.3598e-18
c650 n590__i0__i14__net1 vss 14.6468e-18
c651 n592__i0__i14__net1 vss 14.5246e-18
c652 n9__s vss 25.5333e-18
c653 n3__i3__i1__net2 vss 45.657e-18
c654 n578__i0__i14__net1 vss 14.6468e-18
c655 n580__i0__i14__net1 vss 14.5246e-18
c656 n574__i0__i14__net1 vss 14.6468e-18
c657 n576__i0__i14__net1 vss 13.9817e-18
c658 n8__i3__net13 vss 80.4313e-18
c659 n2__i3__net12 vss 66.2861e-18
c660 n2__reset vss 58.5776e-18
c661 n562__i0__i14__net1 vss 14.6468e-18
c662 n564__i0__i14__net1 vss 14.5246e-18
c663 n558__i0__i14__net1 vss 54.1716e-18
c664 n560__i0__i14__net1 vss 46.0372e-18
c665 n4__i1__net1 vss 83.9054e-18
c666 n14__clk vss 71.5711e-18
c667 n3__i3__net11 vss 20.1382e-18
c668 n546__i0__i14__net1 vss 14.6468e-18
c669 n548__i0__i14__net1 vss 14.5246e-18
c670 n3__i1__i1__net22 vss 42.7745e-18
c671 n542__i0__i14__net1 vss 61.7375e-18
c672 n544__i0__i14__net1 vss 52.3359e-18
c673 n5__i3__net13 vss 14.4336e-18
c674 n530__i0__i14__net1 vss 14.4905e-18
c675 n532__i0__i14__net1 vss 14.0676e-18
c676 n12__clk vss 82.71e-18
c677 n2__i1__net1 vss 72.3994e-18
c678 n2__i3__net13 vss 10.6772e-18
c679 n522__i0__i14__net1 vss 14.319e-18
c680 n524__i0__i14__net1 vss 14.2791e-18
c681 n514__i0__i14__net1 vss 14.1815e-18
c682 n516__i0__i14__net1 vss 14.1434e-18
c683 n3__i1__net3 vss 9.39505e-18
c684 n4__i3__net10 vss 81.2095e-18
c685 n10__clk vss 72.8001e-18
c686 n506__i0__i14__net1 vss 53.9461e-18
c687 n508__i0__i14__net1 vss 61.3569e-18
c688 n498__i0__i14__net1 vss 14.2593e-18
c689 n500__i0__i14__net1 vss 14.1434e-18
c690 n7__s vss 205.1e-18
c691 n4__i1__i9__net4 vss 221.918e-18
c692 n3__i3__i0__net2 vss 45.9881e-18
c693 n490__i0__i14__net1 vss 14.4451e-18
c694 n492__i0__i14__net1 vss 15.6211e-18
c695 n482__i0__i14__net1 vss 14.2593e-18
c696 n484__i0__i14__net1 vss 14.1434e-18
c697 n8__clk vss 80.3287e-18
c698 n2__i3__net10 vss 67.0693e-18
c699 n2__i1__i9__net4 vss 90.7194e-18
c700 n5__s vss 233.567e-18
c701 n478__i0__i14__net1 vss 14.4451e-18
c702 n480__i0__i14__net1 vss 14.9876e-18
c703 n3__i3__net9 vss 19.1348e-18
c704 n2__s vss 26.0081e-18
c705 n466__i0__i14__net1 vss 14.2593e-18
c706 n468__i0__i14__net1 vss 14.1434e-18
c707 n462__i0__i14__net1 vss 14.4451e-18
c708 n464__i0__i14__net1 vss 14.3542e-18
c709 n2__clk vss 17.4997e-18
c710 n5__clk vss 17.9041e-18
c711 n450__i0__i14__net1 vss 60.2591e-18
c712 n452__i0__i14__net1 vss 53.1654e-18
c713 n446__i0__i14__net1 vss 51.2458e-18
c714 n448__i0__i14__net1 vss 61.6201e-18
c715 n434__i0__i14__net1 vss 14.1845e-18
c716 n436__i0__i14__net1 vss 14.0683e-18
c717 n430__i0__i14__net1 vss 51.1173e-18
c718 n432__i0__i14__net1 vss 60.5413e-18
c719 n421__i0__i14__net1 vss 14.2317e-18
c720 n423__i0__i14__net1 vss 14.1471e-18
c721 n410__i0__i14__net1 vss 14.6203e-18
c722 n412__i0__i14__net1 vss 15.1691e-18
c723 n405__i0__i14__net1 vss 14.2317e-18
c724 n407__i0__i14__net1 vss 14.1471e-18
c725 n394__i0__i14__net1 vss 14.6203e-18
c726 n396__i0__i14__net1 vss 14.5357e-18
c727 n389__i0__i14__net1 vss 14.2317e-18
c728 n391__i0__i14__net1 vss 14.1471e-18
c729 n378__i0__i14__net1 vss 51.3299e-18
c730 n380__i0__i14__net1 vss 61.5552e-18
c731 n373__i0__i14__net1 vss 59.8044e-18
c732 n375__i0__i14__net1 vss 40.612e-18
c733 n362__i0__i14__net1 vss 14.6203e-18
c734 n364__i0__i14__net1 vss 14.5357e-18
c735 n357__i0__i14__net1 vss 14.2317e-18
c736 n359__i0__i14__net1 vss 14.1471e-18
c737 n346__i0__i14__net1 vss 50.6986e-18
c738 n348__i0__i14__net1 vss 63.2386e-18
c739 n341__i0__i14__net1 vss 14.2317e-18
c740 n343__i0__i14__net1 vss 14.1471e-18
c741 n330__i0__i14__net1 vss 15.2537e-18
c742 n332__i0__i14__net1 vss 14.5357e-18
c743 n325__i0__i14__net1 vss 14.2317e-18
c744 n327__i0__i14__net1 vss 14.1471e-18
c745 n314__i0__i14__net1 vss 15.2537e-18
c746 n316__i0__i14__net1 vss 14.5357e-18
c747 n309__i0__i14__net1 vss 60.8637e-18
c748 n311__i0__i14__net1 vss 40.5962e-18
c749 n298__i0__i14__net1 vss 15.3391e-18
c750 n300__i0__i14__net1 vss 14.6182e-18
c751 n294__i0__i14__net1 vss 61.0176e-18
c752 n296__i0__i14__net1 vss 39.9634e-18
c753 n286__i0__i14__net1 vss 15.0785e-18
c754 n288__i0__i14__net1 vss 14.3542e-18
c755 n278__i0__i14__net1 vss 61.1124e-18
c756 n280__i0__i14__net1 vss 37.6969e-18
c757 n270__i0__i14__net1 vss 14.1699e-18
c758 n272__i0__i14__net1 vss 14.5909e-18
c759 n258__i0__i14__net1 vss 58.4463e-18
c760 n260__i0__i14__net1 vss 50.6713e-18
c761 n254__i0__i14__net1 vss 14.6468e-18
c762 n256__i0__i14__net1 vss 14.5246e-18
c763 n242__i0__i14__net1 vss 43.1432e-18
c764 n244__i0__i14__net1 vss 50.687e-18
c765 n238__i0__i14__net1 vss 14.6468e-18
c766 n240__i0__i14__net1 vss 14.5246e-18
c767 n226__i0__i14__net1 vss 59.938e-18
c768 n228__i0__i14__net1 vss 53.7216e-18
c769 n222__i0__i14__net1 vss 14.6468e-18
c770 n224__i0__i14__net1 vss 14.5246e-18
c771 n210__i0__i14__net1 vss 42.6937e-18
c772 n212__i0__i14__net1 vss 51.968e-18
c773 n206__i0__i14__net1 vss 14.3702e-18
c774 n208__i0__i14__net1 vss 14.2791e-18
c775 n198__i0__i14__net1 vss 45.1553e-18
c776 n200__i0__i14__net1 vss 37.3728e-18
c777 n190__i0__i14__net1 vss 14.4451e-18
c778 n192__i0__i14__net1 vss 14.3542e-18
c779 n178__i0__i14__net1 vss 45.1553e-18
c780 n180__i0__i14__net1 vss 38.7792e-18
c781 n174__i0__i14__net1 vss 14.4451e-18
c782 n176__i0__i14__net1 vss 14.3542e-18
c783 n162__i0__i14__net1 vss 45.1553e-18
c784 n164__i0__i14__net1 vss 53.1314e-18
c785 n158__i0__i14__net1 vss 14.4451e-18
c786 n160__i0__i14__net1 vss 14.3542e-18
c787 n146__i0__i14__net1 vss 14.2593e-18
c788 n148__i0__i14__net1 vss 14.1434e-18
c789 n142__i0__i14__net1 vss 14.4451e-18
c790 n144__i0__i14__net1 vss 14.3542e-18
c791 n130__i0__i14__net1 vss 14.2593e-18
c792 n132__i0__i14__net1 vss 14.1434e-18
c793 n126__i0__i14__net1 vss 14.4451e-18
c794 n128__i0__i14__net1 vss 14.3542e-18
c795 n114__i0__i14__net1 vss 14.2593e-18
c796 n116__i0__i14__net1 vss 14.1434e-18
c797 n110__i0__i14__net1 vss 14.4451e-18
c798 n112__i0__i14__net1 vss 14.3542e-18
c799 n98__i0__i14__net1 vss 14.2593e-18
c800 n100__i0__i14__net1 vss 14.1434e-18
c801 n94__i0__i14__net1 vss 14.4451e-18
c802 n96__i0__i14__net1 vss 14.3542e-18
c803 n82__i0__i14__net1 vss 43.6645e-18
c804 n84__i0__i14__net1 vss 53.0732e-18
c805 n78__i0__i14__net1 vss 14.3575e-18
c806 n80__i0__i14__net1 vss 14.2695e-18
c807 n65__i0__i14__net1 vss 14.2317e-18
c808 n67__i0__i14__net1 vss 14.1471e-18
c809 n58__i0__i14__net1 vss 14.6203e-18
c810 n60__i0__i14__net1 vss 14.5357e-18
c811 n53__i0__i14__net1 vss 14.2317e-18
c812 n55__i0__i14__net1 vss 14.1471e-18
c813 n50__i0__i14__net1 vss 14.6203e-18
c814 n52__i0__i14__net1 vss 14.5357e-18
c815 n45__i0__i14__net1 vss 14.2317e-18
c816 n47__i0__i14__net1 vss 14.1471e-18
c817 n42__i0__i14__net1 vss 14.6203e-18
c818 n44__i0__i14__net1 vss 14.5357e-18
c819 n37__i0__i14__net1 vss 14.2317e-18
c820 n39__i0__i14__net1 vss 14.1471e-18
c821 n34__i0__i14__net1 vss 14.6203e-18
c822 n36__i0__i14__net1 vss 14.5357e-18
c823 n29__i0__i14__net1 vss 14.2317e-18
c824 n31__i0__i14__net1 vss 14.1471e-18
c825 n26__i0__i14__net1 vss 14.6203e-18
c826 n28__i0__i14__net1 vss 14.5357e-18
c827 n21__i0__i14__net1 vss 14.1556e-18
c828 n23__i0__i14__net1 vss 14.0707e-18
c829 n18__i0__i14__net1 vss 14.7397e-18
c830 n20__i0__i14__net1 vss 14.6235e-18
c831 n14__i0__i14__net1 vss 14.5957e-18
c832 n16__i0__i14__net1 vss 14.5369e-18
c833 n10__i0__i14__net1 vss 14.6881e-18
c834 n12__i0__i14__net1 vss 14.5722e-18
c835 n6__i0__i14__net1 vss 49.2127e-18
c836 n8__i0__i14__net1 vss 41.9888e-18
c837 n4__i0__i14__net1 vss 24.3337e-18
c838 n2__i0__i14__net1 vss 23.535e-18
c839 n19__pinout vss 1.32093e-15
c840 n34__pinin vss 1.31075e-15
c841 n8__pinout vss 1.68959e-15
c842 n23__pinin vss 1.60638e-15
c843 n20__pinin vss 24.8173e-18
c844 n15__reset vss 132.313e-18
c845 n1326__i0__i14__net1 vss 83.4725e-18
c846 n1324__i0__i14__net1 vss 70.3192e-18
c847 n1327__i0__i14__net1 vss 72.2502e-18
c848 n1325__i0__i14__net1 vss 70.2754e-18
c849 n1328__i0__i14__net1 vss 66.1071e-18
c850 n1329__i0__i14__net1 vss 65.5781e-18
c851 n1330__i0__i14__net1 vss 69.2224e-18
c852 n1331__i0__i14__net1 vss 71.3254e-18
c853 n1332__i0__i14__net1 vss 70.5411e-18
c854 n1333__i0__i14__net1 vss 71.444e-18
c855 n1334__i0__i14__net1 vss 68.9805e-18
c856 n1335__i0__i14__net1 vss 76.7592e-18
c857 n1336__i0__i14__net1 vss 87.0934e-18
c858 n777__i0__i14__net1 vss 113.826e-18
c859 n5__r0 vss 15.2319e-18
c860 n38__s vss 245.026e-18
c861 n10__reset vss 397.044e-18
c862 n34__s vss 340.255e-18
c863 n3__r1 vss 32.7844e-18
c864 n26__s vss 30.8531e-18
c865 n5__reset vss 14.0741e-18
c866 n1533__chipdriverout vss 264.943e-18
c867 n1532__chipdriverout vss 250.189e-18
c868 n1531__chipdriverout vss 286.275e-18
c869 n1521__chipdriverout vss 194.454e-18
c870 n1522__chipdriverout vss 205.82e-18
c871 n1523__chipdriverout vss 289.247e-18
c872 n1524__chipdriverout vss 253.034e-18
c873 n1525__chipdriverout vss 288.618e-18
c874 n1526__chipdriverout vss 252.982e-18
c875 n1527__chipdriverout vss 255.943e-18
c876 n1528__chipdriverout vss 253.034e-18
c877 n1529__chipdriverout vss 288.302e-18
c878 n1530__chipdriverout vss 236.63e-18
c879 n5__r2 vss 25.3339e-18
c880 n14__s vss 546.378e-18
c881 n18__pinout vss 16.6575e-18
c882 n33__pinin vss 23.2486e-18
c883 n28__i0__net4 vss 55.2112e-18
c884 n24__i0__net4 vss 95.5124e-18
c885 n63__i0__i12__net1 vss 138.259e-18
c886 n51__i0__i12__net1 vss 31.7008e-18
c887 n52__i0__i12__net1 vss 33.1034e-18
c888 n46__i0__i12__net1 vss 34.18e-18
c889 n44__i0__i12__net1 vss 9.22633e-18
c890 n35__i0__i12__net1 vss 44.7048e-18
c891 n36__i0__i12__net1 vss 9.34807e-18
c892 n31__i0__i12__net1 vss 22.9776e-18
c893 n32__i0__i12__net1 vss 34.6657e-18
c894 n57__i0__net3 vss 108.614e-18
c895 n1695__vddio vss 25.4353e-18
c896 n47__i0__net3 vss 41.1327e-18
c897 n43__i0__net3 vss 38.2205e-18
c898 n37__i0__net3 vss 38.1967e-18
c899 n35__i0__net3 vss 38.1407e-18
c900 n1646__vddio vss 15.5448e-18
c901 n28__i0__net3 vss 84.0878e-18
c902 n184__i0__i13__net1 vss 185.416e-18
c903 n185__i0__i13__net1 vss 209.532e-18
c904 n169__i0__i13__net1 vss 186.769e-18
c905 n170__i0__i13__net1 vss 151.376e-18
c906 n183__i0__i13__net1 vss 203.239e-18
c907 n1649__vddio vss 11.1698e-18
c908 n167__i0__i13__net1 vss 13.896e-18
c909 n168__i0__i13__net1 vss 35.0592e-18
c910 n159__i0__i13__net1 vss 16.9758e-18
c911 n160__i0__i13__net1 vss 50.9435e-18
c912 n1653__vddio vss 26.0638e-18
c913 n153__i0__i13__net1 vss 16.973e-18
c914 n154__i0__i13__net1 vss 51.2004e-18
c915 n1699__vddio vss 26.0671e-18
c916 n143__i0__i13__net1 vss 16.8501e-18
c917 n144__i0__i13__net1 vss 51.2103e-18
c918 n1657__vddio vss 16.1531e-18
c919 n135__i0__i13__net1 vss 16.878e-18
c920 n136__i0__i13__net1 vss 50.9534e-18
c921 n127__i0__i13__net1 vss 39.666e-18
c922 n128__i0__i13__net1 vss 33.8264e-18
c923 n115__i0__i13__net1 vss 16.8724e-18
c924 n116__i0__i13__net1 vss 51.2004e-18
c925 n1701__vddio vss 19.9744e-18
c926 n1662__vddio vss 10.6555e-18
c927 n105__i0__i13__net1 vss 16.8768e-18
c928 n108__i0__i13__net1 vss 50.9525e-18
c929 n1664__vddio vss 16.468e-18
c930 n91__i0__i13__net1 vss 40.0697e-18
c931 n92__i0__i13__net1 vss 34.1872e-18
c932 n1666__vddio vss 40.3188e-18
c933 n75__i0__i13__net1 vss 16.7794e-18
c934 n76__i0__i13__net1 vss 51.1379e-18
c935 n1668__vddio vss 27.803e-18
c936 n59__i0__i13__net1 vss 33.5315e-18
c937 n60__i0__i13__net1 vss 67.2025e-18
c938 n225__i0__net2 vss 98.2425e-18
c939 n226__i0__net2 vss 92.3029e-18
c940 n228__i0__net2 vss 86.1171e-18
c941 n229__i0__net2 vss 103.95e-18
c942 n230__i0__net2 vss 99.649e-18
c943 n1387__vddio vss 62.9091e-18
c944 n1388__vddio vss 76.2153e-18
c945 n1389__vddio vss 26.3615e-18
c946 n1390__vddio vss 26.2442e-18
c947 n1391__vddio vss 25.9986e-18
c948 n1392__vddio vss 33.0139e-18
c949 n1393__vddio vss 25.5433e-18
c950 n222__i0__net2 vss 42.6655e-18
c951 n1311__i0__i14__net1 vss 97.015e-18
c952 n1312__i0__i14__net1 vss 79.0418e-18
c953 n1313__i0__i14__net1 vss 85.9765e-18
c954 n1314__i0__i14__net1 vss 88.6852e-18
c955 n1315__i0__i14__net1 vss 63.9989e-18
c956 n1316__i0__i14__net1 vss 112.734e-18
c957 n1317__i0__i14__net1 vss 86.2342e-18
c958 n1318__i0__i14__net1 vss 96.082e-18
c959 n1319__i0__i14__net1 vss 75.8381e-18
c960 n1320__i0__i14__net1 vss 97.0207e-18
c961 n1321__i0__i14__net1 vss 75.8381e-18
c962 n1322__i0__i14__net1 vss 106.626e-18
c963 n1323__i0__i14__net1 vss 75.3859e-18
c964 n219__i0__net2 vss 37.1949e-18
c965 n1366__vddio vss 103.519e-18
c966 n1367__vddio vss 135.631e-18
c967 n1368__vddio vss 104.265e-18
c968 n1369__vddio vss 105.548e-18
c969 n1370__vddio vss 104.265e-18
c970 n1371__vddio vss 135.631e-18
c971 n1372__vddio vss 103.44e-18
c972 n215__i0__net2 vss 35.5177e-18
c973 n1272__i0__i14__net1 vss 120.948e-18
c974 n1273__i0__i14__net1 vss 105.131e-18
c975 n1274__i0__i14__net1 vss 119.269e-18
c976 n1275__i0__i14__net1 vss 105.131e-18
c977 n1276__i0__i14__net1 vss 70.4213e-18
c978 n1277__i0__i14__net1 vss 114.494e-18
c979 n1278__i0__i14__net1 vss 104.077e-18
c980 n1279__i0__i14__net1 vss 119.086e-18
c981 n1280__i0__i14__net1 vss 104.077e-18
c982 n1281__i0__i14__net1 vss 121.476e-18
c983 n1282__i0__i14__net1 vss 104.077e-18
c984 n1283__i0__i14__net1 vss 135.394e-18
c985 n1284__i0__i14__net1 vss 103.454e-18
c986 n211__i0__net2 vss 37.3742e-18
c987 n1345__vddio vss 103.768e-18
c988 n1346__vddio vss 135.76e-18
c989 n1347__vddio vss 104.417e-18
c990 n1348__vddio vss 105.703e-18
c991 n1349__vddio vss 104.417e-18
c992 n1350__vddio vss 135.76e-18
c993 n1351__vddio vss 103.588e-18
c994 n1439__vddio vss 57.7e-18
c995 n207__i0__net2 vss 35.3846e-18
c996 n1233__i0__i14__net1 vss 120.678e-18
c997 n1234__i0__i14__net1 vss 105.131e-18
c998 n1235__i0__i14__net1 vss 119.269e-18
c999 n1236__i0__i14__net1 vss 105.131e-18
c1000 n1237__i0__i14__net1 vss 70.4213e-18
c1001 n1238__i0__i14__net1 vss 114.386e-18
c1002 n1239__i0__i14__net1 vss 104.506e-18
c1003 n1240__i0__i14__net1 vss 119.48e-18
c1004 n1241__i0__i14__net1 vss 104.506e-18
c1005 n1242__i0__i14__net1 vss 121.848e-18
c1006 n1243__i0__i14__net1 vss 104.506e-18
c1007 n1244__i0__i14__net1 vss 135.727e-18
c1008 n1245__i0__i14__net1 vss 104.133e-18
c1009 n203__i0__net2 vss 37.333e-18
c1010 n1324__vddio vss 103.916e-18
c1011 n1325__vddio vss 135.904e-18
c1012 n1326__vddio vss 104.571e-18
c1013 n1327__vddio vss 105.858e-18
c1014 n1328__vddio vss 104.571e-18
c1015 n1329__vddio vss 135.904e-18
c1016 n1330__vddio vss 103.743e-18
c1017 n1440__vddio vss 58.1426e-18
c1018 n198__i0__net2 vss 35.3846e-18
c1019 n1194__i0__i14__net1 vss 121.044e-18
c1020 n1195__i0__i14__net1 vss 105.131e-18
c1021 n1196__i0__i14__net1 vss 119.269e-18
c1022 n1197__i0__i14__net1 vss 105.131e-18
c1023 n1198__i0__i14__net1 vss 70.3856e-18
c1024 n1199__i0__i14__net1 vss 114.083e-18
c1025 n1200__i0__i14__net1 vss 104.605e-18
c1026 n1201__i0__i14__net1 vss 119.663e-18
c1027 n1202__i0__i14__net1 vss 104.605e-18
c1028 n1203__i0__i14__net1 vss 121.884e-18
c1029 n1204__i0__i14__net1 vss 104.605e-18
c1030 n1205__i0__i14__net1 vss 135.854e-18
c1031 n1206__i0__i14__net1 vss 104.023e-18
c1032 n195__i0__net2 vss 36.6801e-18
c1033 n1303__vddio vss 103.684e-18
c1034 n1304__vddio vss 135.775e-18
c1035 n1305__vddio vss 104.42e-18
c1036 n1306__vddio vss 105.703e-18
c1037 n1307__vddio vss 104.42e-18
c1038 n1308__vddio vss 135.775e-18
c1039 n1309__vddio vss 103.594e-18
c1040 n1501__vddio vss 58.1468e-18
c1041 n191__i0__net2 vss 34.71e-18
c1042 n1155__i0__i14__net1 vss 120.67e-18
c1043 n1156__i0__i14__net1 vss 105.131e-18
c1044 n1157__i0__i14__net1 vss 119.269e-18
c1045 n1158__i0__i14__net1 vss 105.131e-18
c1046 n1159__i0__i14__net1 vss 70.2436e-18
c1047 n1160__i0__i14__net1 vss 114.033e-18
c1048 n1161__i0__i14__net1 vss 104.176e-18
c1049 n1162__i0__i14__net1 vss 119.269e-18
c1050 n1163__i0__i14__net1 vss 104.176e-18
c1051 n1164__i0__i14__net1 vss 121.513e-18
c1052 n1165__i0__i14__net1 vss 104.176e-18
c1053 n1166__i0__i14__net1 vss 135.522e-18
c1054 n1167__i0__i14__net1 vss 103.743e-18
c1055 n187__i0__net2 vss 36.3121e-18
c1056 n1282__vddio vss 103.567e-18
c1057 n1283__vddio vss 135.631e-18
c1058 n1284__vddio vss 104.266e-18
c1059 n1285__vddio vss 105.548e-18
c1060 n1286__vddio vss 104.266e-18
c1061 n1287__vddio vss 135.631e-18
c1062 n1288__vddio vss 103.44e-18
c1063 n183__i0__net2 vss 35.1836e-18
c1064 n1116__i0__i14__net1 vss 120.948e-18
c1065 n1117__i0__i14__net1 vss 105.131e-18
c1066 n1118__i0__i14__net1 vss 119.269e-18
c1067 n1119__i0__i14__net1 vss 105.131e-18
c1068 n1120__i0__i14__net1 vss 70.2436e-18
c1069 n1121__i0__i14__net1 vss 114.442e-18
c1070 n1122__i0__i14__net1 vss 104.077e-18
c1071 n1123__i0__i14__net1 vss 119.086e-18
c1072 n1124__i0__i14__net1 vss 104.077e-18
c1073 n1125__i0__i14__net1 vss 121.476e-18
c1074 n1126__i0__i14__net1 vss 104.077e-18
c1075 n1127__i0__i14__net1 vss 135.394e-18
c1076 n1128__i0__i14__net1 vss 103.454e-18
c1077 n175__i0__net2 vss 37.5435e-18
c1078 n1261__vddio vss 103.768e-18
c1079 n1262__vddio vss 135.76e-18
c1080 n1263__vddio vss 104.417e-18
c1081 n1264__vddio vss 105.703e-18
c1082 n1265__vddio vss 104.417e-18
c1083 n1266__vddio vss 135.76e-18
c1084 n1267__vddio vss 103.588e-18
c1085 n1503__vddio vss 58.0509e-18
c1086 n171__i0__net2 vss 35.0504e-18
c1087 n1077__i0__i14__net1 vss 121.096e-18
c1088 n1078__i0__i14__net1 vss 105.131e-18
c1089 n1079__i0__i14__net1 vss 119.269e-18
c1090 n1080__i0__i14__net1 vss 105.131e-18
c1091 n1081__i0__i14__net1 vss 70.2436e-18
c1092 n1082__i0__i14__net1 vss 114.334e-18
c1093 n1083__i0__i14__net1 vss 104.506e-18
c1094 n1084__i0__i14__net1 vss 119.48e-18
c1095 n1085__i0__i14__net1 vss 104.506e-18
c1096 n1086__i0__i14__net1 vss 121.848e-18
c1097 n1087__i0__i14__net1 vss 104.506e-18
c1098 n1088__i0__i14__net1 vss 135.727e-18
c1099 n1089__i0__i14__net1 vss 103.971e-18
c1100 n169__i0__net2 vss 37.5022e-18
c1101 n1227__vddio vss 101.942e-18
c1102 n1228__vddio vss 133.654e-18
c1103 n1231__vddio vss 102.586e-18
c1104 n1232__vddio vss 103.854e-18
c1105 n1235__vddio vss 102.586e-18
c1106 n1236__vddio vss 133.654e-18
c1107 n1239__vddio vss 101.758e-18
c1108 n1504__vddio vss 57.0047e-18
c1109 n162__i0__net2 vss 35.0504e-18
c1110 n1038__i0__i14__net1 vss 119.079e-18
c1111 n1039__i0__i14__net1 vss 103.418e-18
c1112 n1040__i0__i14__net1 vss 117.222e-18
c1113 n1041__i0__i14__net1 vss 103.418e-18
c1114 n1042__i0__i14__net1 vss 68.9877e-18
c1115 n1043__i0__i14__net1 vss 112.194e-18
c1116 n1044__i0__i14__net1 vss 102.693e-18
c1117 n1045__i0__i14__net1 vss 117.616e-18
c1118 n1046__i0__i14__net1 vss 102.693e-18
c1119 n1047__i0__i14__net1 vss 119.944e-18
c1120 n1048__i0__i14__net1 vss 102.693e-18
c1121 n1049__i0__i14__net1 vss 133.801e-18
c1122 n1050__i0__i14__net1 vss 102.045e-18
c1123 n159__i0__net2 vss 37.4613e-18
c1124 n1219__vddio vss 102.235e-18
c1125 n1220__vddio vss 134.069e-18
c1126 n1221__vddio vss 103.005e-18
c1127 n1222__vddio vss 104.268e-18
c1128 n1223__vddio vss 103.005e-18
c1129 n1224__vddio vss 134.069e-18
c1130 n1225__vddio vss 102.177e-18
c1131 n1505__vddio vss 57.2398e-18
c1132 n147__i0__net2 vss 35.9754e-18
c1133 n999__i0__i14__net1 vss 119.358e-18
c1134 n1000__i0__i14__net1 vss 103.92e-18
c1135 n1001__i0__i14__net1 vss 117.29e-18
c1136 n1002__i0__i14__net1 vss 103.92e-18
c1137 n1003__i0__i14__net1 vss 69.1395e-18
c1138 n1004__i0__i14__net1 vss 112.693e-18
c1139 n1005__i0__i14__net1 vss 102.151e-18
c1140 n1006__i0__i14__net1 vss 116.908e-18
c1141 n1007__i0__i14__net1 vss 102.151e-18
c1142 n1008__i0__i14__net1 vss 119.651e-18
c1143 n1009__i0__i14__net1 vss 102.151e-18
c1144 n1010__i0__i14__net1 vss 133.329e-18
c1145 n1011__i0__i14__net1 vss 101.647e-18
c1146 n143__i0__net2 vss 36.4527e-18
c1147 n1198__vddio vss 103.551e-18
c1148 n1199__vddio vss 135.609e-18
c1149 n1200__vddio vss 104.286e-18
c1150 n1201__vddio vss 105.57e-18
c1151 n1202__vddio vss 104.286e-18
c1152 n1203__vddio vss 135.609e-18
c1153 n1204__vddio vss 103.46e-18
c1154 n131__i0__net2 vss 35.8061e-18
c1155 n960__i0__i14__net1 vss 121.21e-18
c1156 n961__i0__i14__net1 vss 105.675e-18
c1157 n962__i0__i14__net1 vss 119.48e-18
c1158 n963__i0__i14__net1 vss 105.675e-18
c1159 n964__i0__i14__net1 vss 70.5693e-18
c1160 n965__i0__i14__net1 vss 114.134e-18
c1161 n966__i0__i14__net1 vss 104.228e-18
c1162 n967__i0__i14__net1 vss 119.274e-18
c1163 n968__i0__i14__net1 vss 104.228e-18
c1164 n969__i0__i14__net1 vss 121.664e-18
c1165 n970__i0__i14__net1 vss 104.228e-18
c1166 n971__i0__i14__net1 vss 135.619e-18
c1167 n972__i0__i14__net1 vss 103.61e-18
c1168 n127__i0__net2 vss 36.4527e-18
c1169 n1177__vddio vss 103.699e-18
c1170 n1178__vddio vss 135.754e-18
c1171 n1179__vddio vss 104.44e-18
c1172 n1180__vddio vss 105.725e-18
c1173 n1181__vddio vss 104.44e-18
c1174 n1182__vddio vss 135.754e-18
c1175 n1183__vddio vss 103.615e-18
c1176 n1507__vddio vss 58.0106e-18
c1177 n115__i0__net2 vss 35.7962e-18
c1178 n921__i0__i14__net1 vss 120.94e-18
c1179 n922__i0__i14__net1 vss 105.675e-18
c1180 n923__i0__i14__net1 vss 119.48e-18
c1181 n924__i0__i14__net1 vss 105.675e-18
c1182 n925__i0__i14__net1 vss 70.5693e-18
c1183 n926__i0__i14__net1 vss 114.344e-18
c1184 n927__i0__i14__net1 vss 104.587e-18
c1185 n928__i0__i14__net1 vss 119.611e-18
c1186 n929__i0__i14__net1 vss 104.587e-18
c1187 n930__i0__i14__net1 vss 122.01e-18
c1188 n931__i0__i14__net1 vss 104.587e-18
c1189 n932__i0__i14__net1 vss 135.944e-18
c1190 n933__i0__i14__net1 vss 104.156e-18
c1191 n111__i0__net2 vss 36.2928e-18
c1192 n1156__vddio vss 103.855e-18
c1193 n1157__vddio vss 135.856e-18
c1194 n1158__vddio vss 104.513e-18
c1195 n1159__vddio vss 105.799e-18
c1196 n1160__vddio vss 104.513e-18
c1197 n1161__vddio vss 135.856e-18
c1198 n1162__vddio vss 103.685e-18
c1199 n1508__vddio vss 58.1956e-18
c1200 n7__pinout vss 22.9268e-18
c1201 n99__i0__net2 vss 38.2395e-18
c1202 n882__i0__i14__net1 vss 104.483e-18
c1203 n883__i0__i14__net1 vss 121.668e-18
c1204 n884__i0__i14__net1 vss 135.892e-18
c1205 n885__i0__i14__net1 vss 121.876e-18
c1206 n886__i0__i14__net1 vss 89.086e-18
c1207 n887__i0__i14__net1 vss 91.5396e-18
c1208 n888__i0__i14__net1 vss 120.519e-18
c1209 n889__i0__i14__net1 vss 135.904e-18
c1210 n890__i0__i14__net1 vss 120.737e-18
c1211 n891__i0__i14__net1 vss 105.784e-18
c1212 n892__i0__i14__net1 vss 120.519e-18
c1213 n893__i0__i14__net1 vss 119.435e-18
c1214 n894__i0__i14__net1 vss 120.66e-18
c1215 n90__i0__net2 vss 33.7085e-18
c1216 n1135__vddio vss 121.499e-18
c1217 n1136__vddio vss 119.306e-18
c1218 n1137__vddio vss 120.332e-18
c1219 n1138__vddio vss 121.859e-18
c1220 n1139__vddio vss 120.535e-18
c1221 n1140__vddio vss 119.306e-18
c1222 n1141__vddio vss 119.488e-18
c1223 n22__pinin vss 49.3073e-18
c1224 n83__i0__net2 vss 35.2592e-18
c1225 n843__i0__i14__net1 vss 104.752e-18
c1226 n844__i0__i14__net1 vss 121.668e-18
c1227 n845__i0__i14__net1 vss 135.892e-18
c1228 n846__i0__i14__net1 vss 121.876e-18
c1229 n847__i0__i14__net1 vss 69.7899e-18
c1230 n848__i0__i14__net1 vss 114.42e-18
c1231 n849__i0__i14__net1 vss 120.175e-18
c1232 n850__i0__i14__net1 vss 135.579e-18
c1233 n851__i0__i14__net1 vss 104.136e-18
c1234 n852__i0__i14__net1 vss 121.715e-18
c1235 n853__i0__i14__net1 vss 104.136e-18
c1236 n854__i0__i14__net1 vss 135.579e-18
c1237 n855__i0__i14__net1 vss 103.758e-18
c1238 n79__i0__net2 vss 29.5411e-18
c1239 n19__pinin vss 32.7463e-18
c1240 n1114__vddio vss 103.551e-18
c1241 n1115__vddio vss 135.61e-18
c1242 n1116__vddio vss 104.286e-18
c1243 n1117__vddio vss 105.57e-18
c1244 n1118__vddio vss 104.286e-18
c1245 n1119__vddio vss 135.61e-18
c1246 n1120__vddio vss 103.46e-18
c1247 n14__reset vss 37.5699e-18
c1248 n67__i0__net2 vss 45.355e-18
c1249 n804__i0__i14__net1 vss 157.394e-18
c1250 n805__i0__i14__net1 vss 137.204e-18
c1251 n806__i0__i14__net1 vss 155.163e-18
c1252 n807__i0__i14__net1 vss 137.212e-18
c1253 n808__i0__i14__net1 vss 89.944e-18
c1254 n809__i0__i14__net1 vss 140.798e-18
c1255 n810__i0__i14__net1 vss 135.445e-18
c1256 n811__i0__i14__net1 vss 154.144e-18
c1257 n812__i0__i14__net1 vss 135.416e-18
c1258 n813__i0__i14__net1 vss 157.359e-18
c1259 n814__i0__i14__net1 vss 135.401e-18
c1260 n815__i0__i14__net1 vss 174.715e-18
c1261 n816__i0__i14__net1 vss 135.02e-18
c1262 n63__i0__net2 vss 58.4601e-18
c1263 n1093__vddio vss 89.3388e-18
c1264 n1094__vddio vss 120.706e-18
c1265 n1095__vddio vss 89.9478e-18
c1266 n1096__vddio vss 90.9272e-18
c1267 n1097__vddio vss 89.9478e-18
c1268 n1098__vddio vss 120.706e-18
c1269 n1099__vddio vss 89.5514e-18
c1270 n1511__vddio vss 41.7323e-18
c1271 n15__i1__net7 vss 32.354e-18
c1272 n12__i1__net7 vss 36.1178e-18
c1273 n1023__vddio vss 33.3794e-18
c1274 n1024__vddio vss 33.0055e-18
c1275 n1025__vddio vss 25.7874e-18
c1276 n1026__vddio vss 26.0957e-18
c1277 n1027__vddio vss 25.8495e-18
c1278 n1028__vddio vss 33.0055e-18
c1279 n1029__vddio vss 25.3422e-18
c1280 n4__r0 vss 25.3151e-18
c1281 n774__i0__i14__net1 vss 71.9212e-18
c1282 n1911__chipdriverout vss 96.9614e-18
c1283 n1912__chipdriverout vss 75.8337e-18
c1284 n1913__chipdriverout vss 86.1479e-18
c1285 n1914__chipdriverout vss 75.8338e-18
c1286 n1915__chipdriverout vss 55.5854e-18
c1287 n1916__chipdriverout vss 96.8293e-18
c1288 n1917__chipdriverout vss 75.6811e-18
c1289 n1918__chipdriverout vss 85.9368e-18
c1290 n1919__chipdriverout vss 75.6811e-18
c1291 n1920__chipdriverout vss 97.4958e-18
c1292 n1921__chipdriverout vss 75.6811e-18
c1293 n1922__chipdriverout vss 107.049e-18
c1294 n1923__chipdriverout vss 75.1108e-18
c1295 n1455__vddio vss 1.02403e-21
c1296 n771__i0__i14__net1 vss 37.378e-18
c1297 n1002__vddio vss 101.941e-18
c1298 n1003__vddio vss 133.655e-18
c1299 n1004__vddio vss 102.586e-18
c1300 n1005__vddio vss 103.854e-18
c1301 n1006__vddio vss 102.586e-18
c1302 n1007__vddio vss 133.655e-18
c1303 n1008__vddio vss 101.758e-18
c1304 n1031__vddio vss 57.0139e-18
c1305 n765__i0__i14__net1 vss 37.8544e-18
c1306 n7__i1__net6 vss 76.6121e-18
c1307 n1872__chipdriverout vss 104.19e-18
c1308 n1873__chipdriverout vss 120.178e-18
c1309 n1874__chipdriverout vss 135.816e-18
c1310 n1875__chipdriverout vss 120.383e-18
c1311 n1876__chipdriverout vss 90.6566e-18
c1312 n1877__chipdriverout vss 90.2556e-18
c1313 n1878__chipdriverout vss 118.241e-18
c1314 n1879__chipdriverout vss 133.578e-18
c1315 n1880__chipdriverout vss 118.449e-18
c1316 n1881__chipdriverout vss 103.666e-18
c1317 n1882__chipdriverout vss 118.241e-18
c1318 n1883__chipdriverout vss 117.299e-18
c1319 n1884__chipdriverout vss 118.394e-18
c1320 n761__i0__i14__net1 vss 37.5293e-18
c1321 n37__s vss 97.8963e-18
c1322 n967__vddio vss 120.045e-18
c1323 n970__vddio vss 118.339e-18
c1324 n971__vddio vss 119.094e-18
c1325 n974__vddio vss 120.605e-18
c1326 n975__vddio vss 119.296e-18
c1327 n978__vddio vss 118.339e-18
c1328 n979__vddio vss 118.619e-18
c1329 n1032__vddio vss 86.1481e-18
c1330 n759__i0__i14__net1 vss 37.9825e-18
c1331 n6__i1__net6 vss 73.8456e-18
c1332 n1838__chipdriverout vss 114.031e-18
c1333 n1839__chipdriverout vss 118.492e-18
c1334 n1840__chipdriverout vss 133.829e-18
c1335 n1841__chipdriverout vss 118.697e-18
c1336 n1842__chipdriverout vss 120.015e-18
c1337 n1843__chipdriverout vss 102.704e-18
c1338 n1844__chipdriverout vss 133.829e-18
c1339 n1845__chipdriverout vss 124.109e-18
c1340 n1807__chipdriverout vss 103.579e-18
c1341 n1810__chipdriverout vss 103.034e-18
c1342 n1811__chipdriverout vss 134.164e-18
c1343 n1814__chipdriverout vss 119.023e-18
c1344 n1815__chipdriverout vss 89.6588e-18
c1345 n755__i0__i14__net1 vss 35.8533e-18
c1346 n8__reset vss 35.325e-18
c1347 n947__vddio vss 105.714e-18
c1348 n948__vddio vss 137.842e-18
c1349 n951__vddio vss 106.281e-18
c1350 n952__vddio vss 107.589e-18
c1351 n955__vddio vss 106.281e-18
c1352 n956__vddio vss 137.842e-18
c1353 n959__vddio vss 105.455e-18
c1354 n1033__vddio vss 82.1547e-18
c1355 n749__i0__i14__net1 vss 29.2062e-18
c1356 n1794__chipdriverout vss 108.495e-18
c1357 n1795__chipdriverout vss 120.144e-18
c1358 n1796__chipdriverout vss 135.51e-18
c1359 n1797__chipdriverout vss 120.352e-18
c1360 n1798__chipdriverout vss 90.3561e-18
c1361 n1799__chipdriverout vss 93.9057e-18
c1362 n1800__chipdriverout vss 122.028e-18
c1363 n1801__chipdriverout vss 137.632e-18
c1364 n1802__chipdriverout vss 122.235e-18
c1365 n1803__chipdriverout vss 107.524e-18
c1366 n1804__chipdriverout vss 122.028e-18
c1367 n1805__chipdriverout vss 121.377e-18
c1368 n1806__chipdriverout vss 122.208e-18
c1369 n747__i0__i14__net1 vss 34.8337e-18
c1370 n939__vddio vss 122.45e-18
c1371 n940__vddio vss 120.317e-18
c1372 n941__vddio vss 121.219e-18
c1373 n942__vddio vss 122.758e-18
c1374 n943__vddio vss 121.422e-18
c1375 n944__vddio vss 120.317e-18
c1376 n945__vddio vss 120.375e-18
c1377 n1034__vddio vss 81.6321e-18
c1378 n741__i0__i14__net1 vss 37.0845e-18
c1379 n1730__chipdriverout vss 125.782e-18
c1380 n1731__chipdriverout vss 104.861e-18
c1381 n1734__chipdriverout vss 120.065e-18
c1382 n1735__chipdriverout vss 104.861e-18
c1383 n1738__chipdriverout vss 72.3849e-18
c1384 n1739__chipdriverout vss 115.782e-18
c1385 n1742__chipdriverout vss 105.188e-18
c1386 n1743__chipdriverout vss 120.265e-18
c1387 n1746__chipdriverout vss 105.189e-18
c1388 n1747__chipdriverout vss 122.57e-18
c1389 n1750__chipdriverout vss 105.188e-18
c1390 n1751__chipdriverout vss 136.543e-18
c1391 n1754__chipdriverout vss 104.779e-18
c1392 n1459__vddio vss 1.02403e-21
c1393 n32__s vss 9.0262e-18
c1394 n739__i0__i14__net1 vss 37.7499e-18
c1395 n918__vddio vss 102.819e-18
c1396 n919__vddio vss 134.67e-18
c1397 n920__vddio vss 103.469e-18
c1398 n921__vddio vss 104.747e-18
c1399 n922__vddio vss 103.469e-18
c1400 n923__vddio vss 134.67e-18
c1401 n924__vddio vss 102.641e-18
c1402 n1035__vddio vss 57.324e-18
c1403 n20__i1__net1 vss 633.563e-18
c1404 n35__clk vss 545.806e-18
c1405 n737__i0__i14__net1 vss 36.1843e-18
c1406 n1716__chipdriverout vss 124.019e-18
c1407 n1717__chipdriverout vss 103.194e-18
c1408 n1718__chipdriverout vss 118.243e-18
c1409 n1719__chipdriverout vss 103.194e-18
c1410 n1720__chipdriverout vss 71.2556e-18
c1411 n1721__chipdriverout vss 114.261e-18
c1412 n1722__chipdriverout vss 103.233e-18
c1413 n1723__chipdriverout vss 118.128e-18
c1414 n1724__chipdriverout vss 103.233e-18
c1415 n1725__chipdriverout vss 120.627e-18
c1416 n1726__chipdriverout vss 103.233e-18
c1417 n1727__chipdriverout vss 134.437e-18
c1418 n1728__chipdriverout vss 102.599e-18
c1419 n731__i0__i14__net1 vss 36.326e-18
c1420 n897__vddio vss 120.485e-18
c1421 n898__vddio vss 118.411e-18
c1422 n899__vddio vss 119.448e-18
c1423 n900__vddio vss 120.967e-18
c1424 n901__vddio vss 119.65e-18
c1425 n902__vddio vss 118.411e-18
c1426 n903__vddio vss 118.606e-18
c1427 n1036__vddio vss 80.6247e-18
c1428 n15__i1__net5 vss 23.5808e-18
c1429 n729__i0__i14__net1 vss 36.7077e-18
c1430 n1677__chipdriverout vss 107.807e-18
c1431 n1678__chipdriverout vss 119.329e-18
c1432 n1679__chipdriverout vss 134.642e-18
c1433 n1680__chipdriverout vss 119.537e-18
c1434 n1681__chipdriverout vss 89.7802e-18
c1435 n1682__chipdriverout vss 91.4196e-18
c1436 n1683__chipdriverout vss 118.888e-18
c1437 n1684__chipdriverout vss 134.209e-18
c1438 n1685__chipdriverout vss 119.096e-18
c1439 n1686__chipdriverout vss 104.411e-18
c1440 n1687__chipdriverout vss 118.888e-18
c1441 n1688__chipdriverout vss 118.008e-18
c1442 n1689__chipdriverout vss 118.634e-18
c1443 n12__i1__net5 vss 42.122e-18
c1444 n723__i0__i14__net1 vss 37.4786e-18
c1445 n11__i3__net11 vss 135.324e-18
c1446 n14__clk4 vss 56.3739e-18
c1447 n863__vddio vss 102.868e-18
c1448 n864__vddio vss 134.73e-18
c1449 n867__vddio vss 103.518e-18
c1450 n868__vddio vss 104.797e-18
c1451 n871__vddio vss 103.518e-18
c1452 n872__vddio vss 134.73e-18
c1453 n875__vddio vss 102.693e-18
c1454 n1037__vddio vss 81.3536e-18
c1455 n1__r1 vss 60.9717e-18
c1456 n719__i0__i14__net1 vss 38.2053e-18
c1457 n1638__chipdriverout vss 124.444e-18
c1458 n1639__chipdriverout vss 103.407e-18
c1459 n1640__chipdriverout vss 118.301e-18
c1460 n1641__chipdriverout vss 103.407e-18
c1461 n1642__chipdriverout vss 71.2617e-18
c1462 n1643__chipdriverout vss 113.885e-18
c1463 n1644__chipdriverout vss 103.179e-18
c1464 n1645__chipdriverout vss 118.165e-18
c1465 n1646__chipdriverout vss 103.179e-18
c1466 n1647__chipdriverout vss 120.46e-18
c1467 n1648__chipdriverout vss 103.179e-18
c1468 n1649__chipdriverout vss 134.366e-18
c1469 n1650__chipdriverout vss 102.572e-18
c1470 n711__i0__i14__net1 vss 37.3344e-18
c1471 n855__vddio vss 102.434e-18
c1472 n856__vddio vss 134.434e-18
c1473 n857__vddio vss 103.234e-18
c1474 n858__vddio vss 104.505e-18
c1475 n859__vddio vss 103.234e-18
c1476 n860__vddio vss 134.434e-18
c1477 n861__vddio vss 102.408e-18
c1478 n1038__vddio vss 57.6995e-18
c1479 n7__i1__net4 vss 75.919e-18
c1480 n699__i0__i14__net1 vss 38.6434e-18
c1481 n1599__chipdriverout vss 107.852e-18
c1482 n1600__chipdriverout vss 119.341e-18
c1483 n1601__chipdriverout vss 134.657e-18
c1484 n1602__chipdriverout vss 119.548e-18
c1485 n1603__chipdriverout vss 89.8306e-18
c1486 n1604__chipdriverout vss 91.7241e-18
c1487 n1605__chipdriverout vss 119.085e-18
c1488 n1606__chipdriverout vss 134.374e-18
c1489 n1607__chipdriverout vss 119.293e-18
c1490 n1608__chipdriverout vss 104.521e-18
c1491 n1609__chipdriverout vss 119.085e-18
c1492 n1610__chipdriverout vss 118.086e-18
c1493 n1611__chipdriverout vss 119.396e-18
c1494 n1463__vddio vss 1.02403e-21
c1495 n25__s vss 99.1696e-18
c1496 n695__i0__i14__net1 vss 37.2564e-18
c1497 n834__vddio vss 103.639e-18
c1498 n835__vddio vss 135.452e-18
c1499 n836__vddio vss 104.246e-18
c1500 n837__vddio vss 105.536e-18
c1501 n838__vddio vss 104.246e-18
c1502 n839__vddio vss 135.452e-18
c1503 n840__vddio vss 103.424e-18
c1504 n1039__vddio vss 57.9733e-18
c1505 n683__i0__i14__net1 vss 37.5972e-18
c1506 n6__i1__net4 vss 72.0609e-18
c1507 n1560__chipdriverout vss 108.667e-18
c1508 n1561__chipdriverout vss 120.473e-18
c1509 n1562__chipdriverout vss 135.892e-18
c1510 n1563__chipdriverout vss 120.681e-18
c1511 n1564__chipdriverout vss 90.7016e-18
c1512 n1565__chipdriverout vss 92.565e-18
c1513 n1566__chipdriverout vss 120.239e-18
c1514 n1567__chipdriverout vss 135.658e-18
c1515 n1568__chipdriverout vss 120.447e-18
c1516 n1569__chipdriverout vss 105.745e-18
c1517 n1570__chipdriverout vss 120.239e-18
c1518 n1571__chipdriverout vss 119.433e-18
c1519 n1572__chipdriverout vss 120.479e-18
c1520 n10__i3__net12 vss 72.3569e-18
c1521 n679__i0__i14__net1 vss 35.6921e-18
c1522 n3__reset vss 36.5827e-18
c1523 n813__vddio vss 121.367e-18
c1524 n814__vddio vss 119.596e-18
c1525 n815__vddio vss 120.344e-18
c1526 n816__vddio vss 121.875e-18
c1527 n817__vddio vss 120.547e-18
c1528 n818__vddio vss 119.596e-18
c1529 n819__vddio vss 119.505e-18
c1530 n1040__vddio vss 81.5044e-18
c1531 n666__i0__i14__net1 vss 36.4399e-18
c1532 n7__i3__net11 vss 168.328e-18
c1533 n1508__chipdriverout vss 125.35e-18
c1534 n1509__chipdriverout vss 104.5e-18
c1535 n1510__chipdriverout vss 119.48e-18
c1536 n1511__chipdriverout vss 104.5e-18
c1537 n1512__chipdriverout vss 72.2121e-18
c1538 n1513__chipdriverout vss 114.676e-18
c1539 n1514__chipdriverout vss 104.352e-18
c1540 n1515__chipdriverout vss 119.425e-18
c1541 n1516__chipdriverout vss 104.352e-18
c1542 n1517__chipdriverout vss 121.693e-18
c1543 n1518__chipdriverout vss 104.352e-18
c1544 n1519__chipdriverout vss 135.677e-18
c1545 n1520__chipdriverout vss 103.937e-18
c1546 n663__i0__i14__net1 vss 35.2425e-18
c1547 n792__vddio vss 103.551e-18
c1548 n793__vddio vss 135.609e-18
c1549 n794__vddio vss 104.286e-18
c1550 n795__vddio vss 105.57e-18
c1551 n796__vddio vss 104.286e-18
c1552 n797__vddio vss 135.609e-18
c1553 n798__vddio vss 103.46e-18
c1554 n1041__vddio vss 81.0644e-18
c1555 n8__i3__net12 vss 84.2249e-18
c1556 n649__i0__i14__net1 vss 38.4725e-18
c1557 n23__i3__net13 vss 99.6619e-18
c1558 n1470__chipdriverout vss 15.44e-18
c1559 n1471__chipdriverout vss 15.8803e-18
c1560 n1472__chipdriverout vss 15.6389e-18
c1561 n1473__chipdriverout vss 17.7728e-18
c1562 n1475__chipdriverout vss 15.3755e-18
c1563 n1476__chipdriverout vss 15.8193e-18
c1564 n1477__chipdriverout vss 15.5803e-18
c1565 n1479__chipdriverout vss 15.3755e-18
c1566 n1481__chipdriverout vss 16.5121e-18
c1567 n643__i0__i14__net1 vss 87.8925e-18
c1568 n771__vddio vss 150.822e-18
c1569 n772__vddio vss 178.003e-18
c1570 n773__vddio vss 151.191e-18
c1571 n774__vddio vss 152.301e-18
c1572 n775__vddio vss 151.191e-18
c1573 n776__vddio vss 178.003e-18
c1574 n777__vddio vss 149.09e-18
c1575 n1042__vddio vss 68.5737e-18
c1576 n8__i3__net9 vss 127.766e-18
c1577 n28__clk vss 473.567e-18
c1578 n639__i0__i14__net1 vss 90.0979e-18
c1579 n1430__chipdriverout vss 15.9253e-18
c1580 n1435__chipdriverout vss 21.879e-18
c1581 n1439__chipdriverout vss 15.3546e-18
c1582 n1441__chipdriverout vss 15.5662e-18
c1583 n631__i0__i14__net1 vss 35.9103e-18
c1584 n15__i1__net3 vss 22.4414e-18
c1585 n750__vddio vss 103.591e-18
c1586 n751__vddio vss 135.452e-18
c1587 n752__vddio vss 104.246e-18
c1588 n753__vddio vss 105.536e-18
c1589 n754__vddio vss 104.246e-18
c1590 n755__vddio vss 135.452e-18
c1591 n756__vddio vss 103.424e-18
c1592 n1043__vddio vss 57.5049e-18
c1593 n622__i0__i14__net1 vss 36.5539e-18
c1594 n1391__chipdriverout vss 125.49e-18
c1595 n1392__chipdriverout vss 104.5e-18
c1596 n1393__chipdriverout vss 135.892e-18
c1597 n1394__chipdriverout vss 104.5e-18
c1598 n1395__chipdriverout vss 90.7022e-18
c1599 n1396__chipdriverout vss 92.7161e-18
c1600 n1397__chipdriverout vss 120.239e-18
c1601 n1398__chipdriverout vss 119.433e-18
c1602 n1399__chipdriverout vss 120.447e-18
c1603 n1400__chipdriverout vss 105.745e-18
c1604 n1401__chipdriverout vss 120.239e-18
c1605 n1402__chipdriverout vss 119.433e-18
c1606 n1403__chipdriverout vss 120.479e-18
c1607 n12__i1__net3 vss 43.5205e-18
c1608 n615__i0__i14__net1 vss 35.9103e-18
c1609 n729__vddio vss 105.763e-18
c1610 n730__vddio vss 137.914e-18
c1611 n731__vddio vss 106.448e-18
c1612 n732__vddio vss 107.756e-18
c1613 n733__vddio vss 106.448e-18
c1614 n734__vddio vss 137.914e-18
c1615 n735__vddio vss 105.626e-18
c1616 n1044__vddio vss 59.8995e-18
c1617 n4__r2 vss 25.4361e-18
c1618 n607__i0__i14__net1 vss 36.3639e-18
c1619 n1352__chipdriverout vss 126.391e-18
c1620 n1353__chipdriverout vss 105.515e-18
c1621 n1354__chipdriverout vss 120.544e-18
c1622 n1355__chipdriverout vss 105.516e-18
c1623 n1356__chipdriverout vss 72.7098e-18
c1624 n1357__chipdriverout vss 117.021e-18
c1625 n1358__chipdriverout vss 106.46e-18
c1626 n1359__chipdriverout vss 121.693e-18
c1627 n1360__chipdriverout vss 106.46e-18
c1628 n1361__chipdriverout vss 123.813e-18
c1629 n1362__chipdriverout vss 106.46e-18
c1630 n1363__chipdriverout vss 137.931e-18
c1631 n1364__chipdriverout vss 105.899e-18
c1632 n10__i3__net10 vss 68.6761e-18
c1633 n599__i0__i14__net1 vss 35.8271e-18
c1634 n708__vddio vss 121.713e-18
c1635 n709__vddio vss 119.813e-18
c1636 n710__vddio vss 120.581e-18
c1637 n711__vddio vss 122.116e-18
c1638 n712__vddio vss 120.783e-18
c1639 n713__vddio vss 119.813e-18
c1640 n714__vddio vss 119.739e-18
c1641 n1045__vddio vss 58.6311e-18
c1642 n587__i0__i14__net1 vss 37.5687e-18
c1643 n1287__chipdriverout vss 104.827e-18
c1644 n1290__chipdriverout vss 120.835e-18
c1645 n1291__chipdriverout vss 136.467e-18
c1646 n1294__chipdriverout vss 121.04e-18
c1647 n1295__chipdriverout vss 91.0392e-18
c1648 n1298__chipdriverout vss 92.5167e-18
c1649 n1299__chipdriverout vss 120.887e-18
c1650 n1302__chipdriverout vss 136.539e-18
c1651 n1303__chipdriverout vss 121.101e-18
c1652 n1306__chipdriverout vss 106.234e-18
c1653 n1307__chipdriverout vss 120.887e-18
c1654 n1310__chipdriverout vss 120.15e-18
c1655 n1311__chipdriverout vss 120.948e-18
c1656 n7__i3__net9 vss 165.526e-18
c1657 n13__s vss 93.2105e-18
c1658 n583__i0__i14__net1 vss 36.4653e-18
c1659 n687__vddio vss 119.802e-18
c1660 n688__vddio vss 117.625e-18
c1661 n689__vddio vss 118.716e-18
c1662 n690__vddio vss 120.226e-18
c1663 n691__vddio vss 118.919e-18
c1664 n692__vddio vss 117.625e-18
c1665 n693__vddio vss 117.875e-18
c1666 n1046__vddio vss 80.5062e-18
c1667 n571__i0__i14__net1 vss 38.0961e-18
c1668 n8__i3__net10 vss 125.962e-18
c1669 n8__i1__net1 vss 205.97e-18
c1670 n1274__chipdriverout vss 119.21e-18
c1671 n1275__chipdriverout vss 102.689e-18
c1672 n1276__chipdriverout vss 117.569e-18
c1673 n1277__chipdriverout vss 102.689e-18
c1674 n1278__chipdriverout vss 70.9233e-18
c1675 n1279__chipdriverout vss 113.809e-18
c1676 n1280__chipdriverout vss 102.546e-18
c1677 n1281__chipdriverout vss 117.358e-18
c1678 n1282__chipdriverout vss 102.546e-18
c1679 n1283__chipdriverout vss 120.049e-18
c1680 n1284__chipdriverout vss 102.546e-18
c1681 n1285__chipdriverout vss 133.783e-18
c1682 n1286__chipdriverout vss 101.929e-18
c1683 n19__clk vss 153.255e-18
c1684 n20__clk vss 64.999e-18
c1685 n565__i0__i14__net1 vss 37.3517e-18
c1686 n653__vddio vss 102.859e-18
c1687 n654__vddio vss 134.831e-18
c1688 n657__vddio vss 103.565e-18
c1689 n658__vddio vss 104.84e-18
c1690 n661__vddio vss 103.565e-18
c1691 n662__vddio vss 134.831e-18
c1692 n665__vddio vss 103.103e-18
c1693 n1047__vddio vss 57.4672e-18
c1694 n554__i0__i14__net1 vss 36.5767e-18
c1695 n1235__chipdriverout vss 123.227e-18
c1696 n1236__chipdriverout vss 103.127e-18
c1697 n1237__chipdriverout vss 118.079e-18
c1698 n1238__chipdriverout vss 103.127e-18
c1699 n1239__chipdriverout vss 71.1107e-18
c1700 n1240__chipdriverout vss 114.561e-18
c1701 n1241__chipdriverout vss 103.393e-18
c1702 n1242__chipdriverout vss 118.231e-18
c1703 n1243__chipdriverout vss 103.393e-18
c1704 n1244__chipdriverout vss 120.92e-18
c1705 n1245__chipdriverout vss 103.393e-18
c1706 n1246__chipdriverout vss 134.67e-18
c1707 n1247__chipdriverout vss 103.35e-18
c1708 n551__i0__i14__net1 vss 36.565e-18
c1709 n645__vddio vss 105.539e-18
c1710 n646__vddio vss 137.822e-18
c1711 n647__vddio vss 106.197e-18
c1712 n648__vddio vss 107.501e-18
c1713 n649__vddio vss 106.197e-18
c1714 n650__vddio vss 137.822e-18
c1715 n651__vddio vss 105.369e-18
c1716 n1048__vddio vss 82.0473e-18
c1717 n538__i0__i14__net1 vss 35.8776e-18
c1718 n1196__chipdriverout vss 122.024e-18
c1719 n1197__chipdriverout vss 105.613e-18
c1720 n1198__chipdriverout vss 120.731e-18
c1721 n1199__chipdriverout vss 105.613e-18
c1722 n1200__chipdriverout vss 72.8551e-18
c1723 n1201__chipdriverout vss 116.652e-18
c1724 n1202__chipdriverout vss 106.224e-18
c1725 n1203__chipdriverout vss 121.344e-18
c1726 n1204__chipdriverout vss 106.224e-18
c1727 n1205__chipdriverout vss 123.819e-18
c1728 n1206__chipdriverout vss 106.224e-18
c1729 n1207__chipdriverout vss 137.816e-18
c1730 n1208__chipdriverout vss 105.846e-18
c1731 n535__i0__i14__net1 vss 36.2986e-18
c1732 n611__vddio vss 104.946e-18
c1733 n612__vddio vss 137.111e-18
c1734 n615__vddio vss 105.619e-18
c1735 n616__vddio vss 106.923e-18
c1736 n619__vddio vss 105.619e-18
c1737 n620__vddio vss 137.111e-18
c1738 n623__vddio vss 104.793e-18
c1739 n1049__vddio vss 82.0787e-18
c1740 n527__i0__i14__net1 vss 35.7516e-18
c1741 n1132__chipdriverout vss 121.988e-18
c1742 n1133__chipdriverout vss 105.759e-18
c1743 n1136__chipdriverout vss 121.022e-18
c1744 n1137__chipdriverout vss 105.759e-18
c1745 n1140__chipdriverout vss 73.0572e-18
c1746 n1141__chipdriverout vss 115.675e-18
c1747 n1144__chipdriverout vss 105.725e-18
c1748 n1145__chipdriverout vss 120.988e-18
c1749 n1148__chipdriverout vss 105.725e-18
c1750 n1149__chipdriverout vss 123.257e-18
c1751 n1152__chipdriverout vss 105.725e-18
c1752 n1153__chipdriverout vss 137.408e-18
c1753 n1156__chipdriverout vss 105.295e-18
c1754 n519__i0__i14__net1 vss 36.8789e-18
c1755 n603__vddio vss 101.477e-18
c1756 n604__vddio vss 133.254e-18
c1757 n605__vddio vss 102.202e-18
c1758 n606__vddio vss 103.468e-18
c1759 n607__vddio vss 102.202e-18
c1760 n608__vddio vss 133.254e-18
c1761 n609__vddio vss 101.376e-18
c1762 n1050__vddio vss 79.923e-18
c1763 n511__i0__i14__net1 vss 35.756e-18
c1764 n1093__chipdriverout vss 118.943e-18
c1765 n1094__chipdriverout vss 102.389e-18
c1766 n1097__chipdriverout vss 117.385e-18
c1767 n1098__chipdriverout vss 102.389e-18
c1768 n1101__chipdriverout vss 70.6569e-18
c1769 n1102__chipdriverout vss 112.406e-18
c1770 n1105__chipdriverout vss 102.412e-18
c1771 n1106__chipdriverout vss 117.31e-18
c1772 n1109__chipdriverout vss 102.413e-18
c1773 n1110__chipdriverout vss 119.759e-18
c1774 n1113__chipdriverout vss 102.412e-18
c1775 n1114__chipdriverout vss 133.589e-18
c1776 n1117__chipdriverout vss 101.734e-18
c1777 n503__i0__i14__net1 vss 36.7934e-18
c1778 n569__vddio vss 102.089e-18
c1779 n570__vddio vss 133.961e-18
c1780 n573__vddio vss 102.794e-18
c1781 n574__vddio vss 104.06e-18
c1782 n577__vddio vss 102.794e-18
c1783 n578__vddio vss 133.961e-18
c1784 n581__vddio vss 102.27e-18
c1785 n1051__vddio vss 57.062e-18
c1786 n494__i0__i14__net1 vss 36.3306e-18
c1787 n1079__chipdriverout vss 122.044e-18
c1788 n1080__chipdriverout vss 102.243e-18
c1789 n1081__chipdriverout vss 117.093e-18
c1790 n1082__chipdriverout vss 102.243e-18
c1791 n1083__chipdriverout vss 70.5252e-18
c1792 n1084__chipdriverout vss 113.097e-18
c1793 n1085__chipdriverout vss 102.51e-18
c1794 n1086__chipdriverout vss 117.246e-18
c1795 n1087__chipdriverout vss 102.51e-18
c1796 n1088__chipdriverout vss 119.998e-18
c1797 n1089__chipdriverout vss 102.51e-18
c1798 n1090__chipdriverout vss 133.654e-18
c1799 n1091__chipdriverout vss 102.431e-18
c1800 n485__i0__i14__net1 vss 36.0549e-18
c1801 n561__vddio vss 105.433e-18
c1802 n562__vddio vss 137.667e-18
c1803 n563__vddio vss 106.058e-18
c1804 n564__vddio vss 107.362e-18
c1805 n565__vddio vss 106.058e-18
c1806 n566__vddio vss 137.667e-18
c1807 n567__vddio vss 105.23e-18
c1808 n1052__vddio vss 58.8868e-18
c1809 n475__i0__i14__net1 vss 36.4155e-18
c1810 n1040__chipdriverout vss 122.332e-18
c1811 n1041__chipdriverout vss 105.613e-18
c1812 n1042__chipdriverout vss 120.685e-18
c1813 n1043__chipdriverout vss 105.614e-18
c1814 n1044__chipdriverout vss 72.9159e-18
c1815 n1045__chipdriverout vss 116.268e-18
c1816 n1046__chipdriverout vss 105.995e-18
c1817 n1047__chipdriverout vss 121.071e-18
c1818 n1048__chipdriverout vss 105.995e-18
c1819 n1049__chipdriverout vss 123.597e-18
c1820 n1050__chipdriverout vss 105.995e-18
c1821 n1051__chipdriverout vss 137.554e-18
c1822 n1052__chipdriverout vss 105.476e-18
c1823 n471__i0__i14__net1 vss 35.9292e-18
c1824 n527__vddio vss 103.721e-18
c1825 n528__vddio vss 135.719e-18
c1826 n531__vddio vss 104.357e-18
c1827 n532__vddio vss 105.653e-18
c1828 n535__vddio vss 104.357e-18
c1829 n536__vddio vss 135.719e-18
c1830 n539__vddio vss 103.532e-18
c1831 n1053__vddio vss 57.9956e-18
c1832 n458__i0__i14__net1 vss 35.5498e-18
c1833 n1001__chipdriverout vss 124.754e-18
c1834 n1002__chipdriverout vss 105.371e-18
c1835 n1003__chipdriverout vss 120.523e-18
c1836 n1004__chipdriverout vss 105.324e-18
c1837 n1005__chipdriverout vss 72.8227e-18
c1838 n1006__chipdriverout vss 114.64e-18
c1839 n1007__chipdriverout vss 104.967e-18
c1840 n1008__chipdriverout vss 120.21e-18
c1841 n1009__chipdriverout vss 104.967e-18
c1842 n1010__chipdriverout vss 122.34e-18
c1843 n1011__chipdriverout vss 104.967e-18
c1844 n1012__chipdriverout vss 136.493e-18
c1845 n1013__chipdriverout vss 104.749e-18
c1846 n455__i0__i14__net1 vss 36.6262e-18
c1847 n519__vddio vss 103.69e-18
c1848 n520__vddio vss 135.739e-18
c1849 n521__vddio vss 104.419e-18
c1850 n522__vddio vss 105.703e-18
c1851 n523__vddio vss 104.419e-18
c1852 n524__vddio vss 135.739e-18
c1853 n525__vddio vss 103.898e-18
c1854 n1054__vddio vss 85.8133e-18
c1855 n443__i0__i14__net1 vss 36.2292e-18
c1856 n962__chipdriverout vss 120.333e-18
c1857 n963__chipdriverout vss 103.905e-18
c1858 n964__chipdriverout vss 118.917e-18
c1859 n965__chipdriverout vss 103.905e-18
c1860 n966__chipdriverout vss 71.849e-18
c1861 n967__chipdriverout vss 114.48e-18
c1862 n968__chipdriverout vss 104.348e-18
c1863 n969__chipdriverout vss 119.298e-18
c1864 n970__chipdriverout vss 104.348e-18
c1865 n971__chipdriverout vss 121.802e-18
c1866 n972__chipdriverout vss 104.348e-18
c1867 n973__chipdriverout vss 135.657e-18
c1868 n974__chipdriverout vss 103.795e-18
c1869 n439__i0__i14__net1 vss 36.0532e-18
c1870 n498__vddio vss 105.648e-18
c1871 n499__vddio vss 137.66e-18
c1872 n500__vddio vss 106.249e-18
c1873 n501__vddio vss 107.558e-18
c1874 n502__vddio vss 106.249e-18
c1875 n503__vddio vss 137.66e-18
c1876 n504__vddio vss 105.427e-18
c1877 n1055__vddio vss 59.1676e-18
c1878 n427__i0__i14__net1 vss 35.9537e-18
c1879 n898__chipdriverout vss 120.706e-18
c1880 n899__chipdriverout vss 104.647e-18
c1881 n902__chipdriverout vss 119.383e-18
c1882 n903__chipdriverout vss 104.554e-18
c1883 n906__chipdriverout vss 72.2239e-18
c1884 n907__chipdriverout vss 116.72e-18
c1885 n910__chipdriverout vss 106.249e-18
c1886 n911__chipdriverout vss 121.384e-18
c1887 n914__chipdriverout vss 106.249e-18
c1888 n915__chipdriverout vss 123.8e-18
c1889 n918__chipdriverout vss 106.249e-18
c1890 n919__chipdriverout vss 137.82e-18
c1891 n922__chipdriverout vss 105.897e-18
c1892 n417__i0__i14__net1 vss 37.1991e-18
c1893 n477__vddio vss 102.066e-18
c1894 n478__vddio vss 117.631e-18
c1895 n479__vddio vss 102.737e-18
c1896 n480__vddio vss 104.015e-18
c1897 n481__vddio vss 102.737e-18
c1898 n482__vddio vss 133.853e-18
c1899 n483__vddio vss 101.915e-18
c1900 n1056__vddio vss 80.169e-18
c1901 n415__i0__i14__net1 vss 36.783e-18
c1902 n892__chipdriverout vss 119.533e-18
c1903 n893__chipdriverout vss 118.767e-18
c1904 n894__chipdriverout vss 117.562e-18
c1905 n895__chipdriverout vss 103.079e-18
c1906 n896__chipdriverout vss 71.2706e-18
c1907 n858__chipdriverout vss 114.068e-18
c1908 n861__chipdriverout vss 119.033e-18
c1909 n862__chipdriverout vss 134.54e-18
c1910 n865__chipdriverout vss 119.238e-18
c1911 n866__chipdriverout vss 120.544e-18
c1912 n869__chipdriverout vss 103.209e-18
c1913 n870__chipdriverout vss 134.54e-18
c1914 n873__chipdriverout vss 123.985e-18
c1915 n401__i0__i14__net1 vss 37.3153e-18
c1916 n456__vddio vss 101.754e-18
c1917 n457__vddio vss 133.634e-18
c1918 n458__vddio vss 102.464e-18
c1919 n459__vddio vss 103.728e-18
c1920 n460__vddio vss 102.464e-18
c1921 n461__vddio vss 133.634e-18
c1922 n462__vddio vss 101.943e-18
c1923 n1057__vddio vss 85.015e-18
c1924 n399__i0__i14__net1 vss 36.4185e-18
c1925 n845__chipdriverout vss 123.732e-18
c1926 n846__chipdriverout vss 104.25e-18
c1927 n847__chipdriverout vss 119.318e-18
c1928 n848__chipdriverout vss 104.25e-18
c1929 n849__chipdriverout vss 72.1572e-18
c1930 n850__chipdriverout vss 113.453e-18
c1931 n851__chipdriverout vss 102.548e-18
c1932 n852__chipdriverout vss 117.314e-18
c1933 n853__chipdriverout vss 102.548e-18
c1934 n854__chipdriverout vss 119.936e-18
c1935 n855__chipdriverout vss 102.548e-18
c1936 n856__chipdriverout vss 133.626e-18
c1937 n857__chipdriverout vss 102.32e-18
c1938 n385__i0__i14__net1 vss 36.6614e-18
c1939 n435__vddio vss 103.919e-18
c1940 n436__vddio vss 135.755e-18
c1941 n437__vddio vss 104.543e-18
c1942 n438__vddio vss 105.831e-18
c1943 n439__vddio vss 104.543e-18
c1944 n440__vddio vss 135.755e-18
c1945 n441__vddio vss 104.022e-18
c1946 n1058__vddio vss 85.0689e-18
c1947 n383__i0__i14__net1 vss 36.2285e-18
c1948 n806__chipdriverout vss 120.791e-18
c1949 n807__chipdriverout vss 104.468e-18
c1950 n808__chipdriverout vss 119.632e-18
c1951 n809__chipdriverout vss 104.468e-18
c1952 n810__chipdriverout vss 72.5766e-18
c1953 n811__chipdriverout vss 115.398e-18
c1954 n812__chipdriverout vss 104.534e-18
c1955 n813__chipdriverout vss 119.504e-18
c1956 n814__chipdriverout vss 104.534e-18
c1957 n815__chipdriverout vss 122e-18
c1958 n816__chipdriverout vss 104.534e-18
c1959 n817__chipdriverout vss 135.876e-18
c1960 n818__chipdriverout vss 103.939e-18
c1961 n1483__vddio vss 1.02403e-21
c1962 n369__i0__i14__net1 vss 36.8753e-18
c1963 n414__vddio vss 105.442e-18
c1964 n415__vddio vss 137.585e-18
c1965 n416__vddio vss 106.108e-18
c1966 n417__vddio vss 107.414e-18
c1967 n418__vddio vss 106.108e-18
c1968 n419__vddio vss 137.585e-18
c1969 n420__vddio vss 105.282e-18
c1970 n1059__vddio vss 59.5244e-18
c1971 n367__i0__i14__net1 vss 36.6628e-18
c1972 n767__chipdriverout vss 122.697e-18
c1973 n768__chipdriverout vss 106.017e-18
c1974 n769__chipdriverout vss 121.239e-18
c1975 n770__chipdriverout vss 106.017e-18
c1976 n771__chipdriverout vss 73.5803e-18
c1977 n772__chipdriverout vss 117.182e-18
c1978 n773__chipdriverout vss 105.928e-18
c1979 n774__chipdriverout vss 120.949e-18
c1980 n775__chipdriverout vss 105.928e-18
c1981 n776__chipdriverout vss 123.485e-18
c1982 n777__chipdriverout vss 105.928e-18
c1983 n778__chipdriverout vss 137.384e-18
c1984 n779__chipdriverout vss 105.397e-18
c1985 n353__i0__i14__net1 vss 37.1292e-18
c1986 n393__vddio vss 104.482e-18
c1987 n394__vddio vss 136.377e-18
c1988 n395__vddio vss 105.023e-18
c1989 n396__vddio vss 106.325e-18
c1990 n397__vddio vss 105.023e-18
c1991 n398__vddio vss 136.377e-18
c1992 n399__vddio vss 104.198e-18
c1993 n1060__vddio vss 57.9949e-18
c1994 n351__i0__i14__net1 vss 35.9556e-18
c1995 n703__chipdriverout vss 121.184e-18
c1996 n704__chipdriverout vss 104.867e-18
c1997 n707__chipdriverout vss 120.1e-18
c1998 n708__chipdriverout vss 104.867e-18
c1999 n711__chipdriverout vss 72.3709e-18
c2000 n712__chipdriverout vss 115.742e-18
c2001 n715__chipdriverout vss 105.038e-18
c2002 n716__chipdriverout vss 120.131e-18
c2003 n719__chipdriverout vss 105.038e-18
c2004 n720__chipdriverout vss 122.507e-18
c2005 n723__chipdriverout vss 105.038e-18
c2006 n724__chipdriverout vss 136.498e-18
c2007 n727__chipdriverout vss 104.6e-18
c2008 n337__i0__i14__net1 vss 38.2114e-18
c2009 n372__vddio vss 120.527e-18
c2010 n373__vddio vss 118.334e-18
c2011 n374__vddio vss 119.393e-18
c2012 n375__vddio vss 120.91e-18
c2013 n376__vddio vss 119.596e-18
c2014 n377__vddio vss 118.334e-18
c2015 n378__vddio vss 118.548e-18
c2016 n1061__vddio vss 57.6296e-18
c2017 n335__i0__i14__net1 vss 36.0926e-18
c2018 n664__chipdriverout vss 119.78e-18
c2019 n665__chipdriverout vss 103.205e-18
c2020 n668__chipdriverout vss 118.233e-18
c2021 n669__chipdriverout vss 103.205e-18
c2022 n672__chipdriverout vss 71.4771e-18
c2023 n673__chipdriverout vss 114.155e-18
c2024 n676__chipdriverout vss 103.425e-18
c2025 n677__chipdriverout vss 118.297e-18
c2026 n680__chipdriverout vss 103.425e-18
c2027 n681__chipdriverout vss 120.727e-18
c2028 n684__chipdriverout vss 103.425e-18
c2029 n685__chipdriverout vss 134.513e-18
c2030 n688__chipdriverout vss 102.844e-18
c2031 n321__i0__i14__net1 vss 37.27e-18
c2032 n351__vddio vss 121.695e-18
c2033 n352__vddio vss 119.537e-18
c2034 n353__vddio vss 120.505e-18
c2035 n354__vddio vss 122.033e-18
c2036 n355__vddio vss 120.707e-18
c2037 n356__vddio vss 119.537e-18
c2038 n357__vddio vss 120.027e-18
c2039 n1062__vddio vss 57.214e-18
c2040 n319__i0__i14__net1 vss 35.4485e-18
c2041 n625__chipdriverout vss 124.467e-18
c2042 n626__chipdriverout vss 104.578e-18
c2043 n629__chipdriverout vss 119.562e-18
c2044 n630__chipdriverout vss 104.578e-18
c2045 n633__chipdriverout vss 72.5736e-18
c2046 n634__chipdriverout vss 114.77e-18
c2047 n637__chipdriverout vss 104.605e-18
c2048 n638__chipdriverout vss 119.663e-18
c2049 n641__chipdriverout vss 104.605e-18
c2050 n642__chipdriverout vss 121.884e-18
c2051 n645__chipdriverout vss 104.605e-18
c2052 n646__chipdriverout vss 135.854e-18
c2053 n649__chipdriverout vss 104.336e-18
c2054 n305__i0__i14__net1 vss 36.8809e-18
c2055 n330__vddio vss 121.252e-18
c2056 n331__vddio vss 119.545e-18
c2057 n332__vddio vss 120.215e-18
c2058 n333__vddio vss 121.738e-18
c2059 n334__vddio vss 120.417e-18
c2060 n335__vddio vss 119.545e-18
c2061 n336__vddio vss 119.374e-18
c2062 n1063__vddio vss 80.5804e-18
c2063 n303__i0__i14__net1 vss 36.0175e-18
c2064 n586__chipdriverout vss 120.41e-18
c2065 n587__chipdriverout vss 104.578e-18
c2066 n590__chipdriverout vss 119.562e-18
c2067 n591__chipdriverout vss 104.578e-18
c2068 n594__chipdriverout vss 72.5736e-18
c2069 n595__chipdriverout vss 114.827e-18
c2070 n598__chipdriverout vss 104.176e-18
c2071 n599__chipdriverout vss 119.269e-18
c2072 n602__chipdriverout vss 104.176e-18
c2073 n603__chipdriverout vss 121.513e-18
c2074 n606__chipdriverout vss 104.176e-18
c2075 n607__chipdriverout vss 135.522e-18
c2076 n610__chipdriverout vss 103.949e-18
c2077 n289__i0__i14__net1 vss 36.9107e-18
c2078 n309__vddio vss 121.144e-18
c2079 n310__vddio vss 119.362e-18
c2080 n311__vddio vss 120.1e-18
c2081 n312__vddio vss 121.623e-18
c2082 n313__vddio vss 120.302e-18
c2083 n314__vddio vss 119.362e-18
c2084 n315__vddio vss 119.259e-18
c2085 n1064__vddio vss 80.8716e-18
c2086 n283__i0__i14__net1 vss 36.0175e-18
c2087 n547__chipdriverout vss 120.779e-18
c2088 n548__chipdriverout vss 104.578e-18
c2089 n551__chipdriverout vss 119.562e-18
c2090 n552__chipdriverout vss 104.578e-18
c2091 n555__chipdriverout vss 72.5736e-18
c2092 n556__chipdriverout vss 115.224e-18
c2093 n559__chipdriverout vss 104.077e-18
c2094 n560__chipdriverout vss 119.086e-18
c2095 n563__chipdriverout vss 104.077e-18
c2096 n564__chipdriverout vss 121.476e-18
c2097 n567__chipdriverout vss 104.077e-18
c2098 n568__chipdriverout vss 135.394e-18
c2099 n571__chipdriverout vss 103.655e-18
c2100 n273__i0__i14__net1 vss 38.0561e-18
c2101 n288__vddio vss 121.57e-18
c2102 n289__vddio vss 119.354e-18
c2103 n290__vddio vss 120.39e-18
c2104 n291__vddio vss 121.918e-18
c2105 n292__vddio vss 120.593e-18
c2106 n293__vddio vss 119.354e-18
c2107 n294__vddio vss 119.545e-18
c2108 n1065__vddio vss 81.8078e-18
c2109 n267__i0__i14__net1 vss 35.9302e-18
c2110 n508__chipdriverout vss 121.05e-18
c2111 n509__chipdriverout vss 104.578e-18
c2112 n512__chipdriverout vss 119.562e-18
c2113 n513__chipdriverout vss 104.578e-18
c2114 n516__chipdriverout vss 72.5736e-18
c2115 n517__chipdriverout vss 115.167e-18
c2116 n520__chipdriverout vss 104.506e-18
c2117 n521__chipdriverout vss 119.48e-18
c2118 n524__chipdriverout vss 104.506e-18
c2119 n525__chipdriverout vss 121.848e-18
c2120 n528__chipdriverout vss 104.506e-18
c2121 n529__chipdriverout vss 135.727e-18
c2122 n532__chipdriverout vss 103.907e-18
c2123 n263__i0__i14__net1 vss 38.0263e-18
c2124 n267__vddio vss 122.408e-18
c2125 n268__vddio vss 120.343e-18
c2126 n269__vddio vss 121.239e-18
c2127 n270__vddio vss 122.776e-18
c2128 n271__vddio vss 121.442e-18
c2129 n272__vddio vss 120.343e-18
c2130 n273__vddio vss 120.699e-18
c2131 n1066__vddio vss 58.5481e-18
c2132 n251__i0__i14__net1 vss 35.9302e-18
c2133 n469__chipdriverout vss 124.681e-18
c2134 n470__chipdriverout vss 105.064e-18
c2135 n473__chipdriverout vss 120.013e-18
c2136 n474__chipdriverout vss 105.064e-18
c2137 n477__chipdriverout vss 72.5184e-18
c2138 n478__chipdriverout vss 115.747e-18
c2139 n481__chipdriverout vss 105.076e-18
c2140 n482__chipdriverout vss 120.12e-18
c2141 n485__chipdriverout vss 105.076e-18
c2142 n486__chipdriverout vss 122.459e-18
c2143 n489__chipdriverout vss 105.076e-18
c2144 n490__chipdriverout vss 136.398e-18
c2145 n493__chipdriverout vss 104.836e-18
c2146 n1491__vddio vss 1.02403e-21
c2147 n247__i0__i14__net1 vss 37.9752e-18
c2148 n246__vddio vss 102.911e-18
c2149 n247__vddio vss 134.773e-18
c2150 n248__vddio vss 103.521e-18
c2151 n249__vddio vss 104.799e-18
c2152 n250__vddio vss 103.521e-18
c2153 n251__vddio vss 134.773e-18
c2154 n252__vddio vss 102.693e-18
c2155 n1067__vddio vss 57.5502e-18
c2156 n235__i0__i14__net1 vss 35.1158e-18
c2157 n455__chipdriverout vss 120.186e-18
c2158 n456__chipdriverout vss 103.466e-18
c2159 n457__chipdriverout vss 118.498e-18
c2160 n458__chipdriverout vss 103.466e-18
c2161 n459__chipdriverout vss 71.557e-18
c2162 n460__chipdriverout vss 114.214e-18
c2163 n461__chipdriverout vss 103.477e-18
c2164 n462__chipdriverout vss 118.414e-18
c2165 n463__chipdriverout vss 103.478e-18
c2166 n464__chipdriverout vss 120.941e-18
c2167 n465__chipdriverout vss 103.477e-18
c2168 n466__chipdriverout vss 134.797e-18
c2169 n467__chipdriverout vss 102.832e-18
c2170 n231__i0__i14__net1 vss 38.8104e-18
c2171 n225__vddio vss 101.995e-18
c2172 n226__vddio vss 133.862e-18
c2173 n227__vddio vss 102.759e-18
c2174 n228__vddio vss 104.024e-18
c2175 n229__vddio vss 102.759e-18
c2176 n230__vddio vss 133.862e-18
c2177 n231__vddio vss 101.934e-18
c2178 n1068__vddio vss 56.9253e-18
c2179 n219__i0__i14__net1 vss 35.9975e-18
c2180 n416__chipdriverout vss 119.031e-18
c2181 n417__chipdriverout vss 102.543e-18
c2182 n418__chipdriverout vss 117.314e-18
c2183 n419__chipdriverout vss 102.543e-18
c2184 n420__chipdriverout vss 70.9413e-18
c2185 n421__chipdriverout vss 113.35e-18
c2186 n422__chipdriverout vss 102.445e-18
c2187 n423__chipdriverout vss 117.211e-18
c2188 n424__chipdriverout vss 102.445e-18
c2189 n425__chipdriverout vss 119.682e-18
c2190 n426__chipdriverout vss 102.445e-18
c2191 n427__chipdriverout vss 133.373e-18
c2192 n428__chipdriverout vss 102.087e-18
c2193 n215__i0__i14__net1 vss 37.7455e-18
c2194 n204__vddio vss 104.032e-18
c2195 n205__vddio vss 135.879e-18
c2196 n206__vddio vss 104.694e-18
c2197 n207__vddio vss 105.982e-18
c2198 n208__vddio vss 104.694e-18
c2199 n209__vddio vss 135.879e-18
c2200 n210__vddio vss 103.869e-18
c2201 n1069__vddio vss 81.3682e-18
c2202 n203__i0__i14__net1 vss 36.0848e-18
c2203 n377__chipdriverout vss 121.3e-18
c2204 n378__chipdriverout vss 104.528e-18
c2205 n379__chipdriverout vss 119.504e-18
c2206 n380__chipdriverout vss 104.528e-18
c2207 n381__chipdriverout vss 72.3677e-18
c2208 n382__chipdriverout vss 114.933e-18
c2209 n383__chipdriverout vss 104.527e-18
c2210 n384__chipdriverout vss 119.605e-18
c2211 n385__chipdriverout vss 104.528e-18
c2212 n386__chipdriverout vss 121.877e-18
c2213 n387__chipdriverout vss 104.527e-18
c2214 n388__chipdriverout vss 135.864e-18
c2215 n389__chipdriverout vss 103.907e-18
c2216 n193__i0__i14__net1 vss 37.0067e-18
c2217 n183__vddio vss 103.534e-18
c2218 n184__vddio vss 135.551e-18
c2219 n185__vddio vss 104.253e-18
c2220 n186__vddio vss 105.536e-18
c2221 n187__vddio vss 104.253e-18
c2222 n188__vddio vss 135.551e-18
c2223 n189__vddio vss 103.729e-18
c2224 n1070__vddio vss 87.3227e-18
c2225 n187__i0__i14__net1 vss 35.3591e-18
c2226 n338__chipdriverout vss 124.308e-18
c2227 n339__chipdriverout vss 104.528e-18
c2228 n340__chipdriverout vss 119.504e-18
c2229 n341__chipdriverout vss 104.528e-18
c2230 n342__chipdriverout vss 72.4607e-18
c2231 n343__chipdriverout vss 114.324e-18
c2232 n344__chipdriverout vss 104.385e-18
c2233 n345__chipdriverout vss 119.435e-18
c2234 n346__chipdriverout vss 104.385e-18
c2235 n347__chipdriverout vss 121.848e-18
c2236 n348__chipdriverout vss 104.385e-18
c2237 n349__chipdriverout vss 135.807e-18
c2238 n350__chipdriverout vss 104.267e-18
c2239 n1495__vddio vss 1.02403e-21
c2240 n183__i0__i14__net1 vss 36.4049e-18
c2241 n162__vddio vss 103.417e-18
c2242 n163__vddio vss 135.426e-18
c2243 n164__vddio vss 104.102e-18
c2244 n165__vddio vss 105.385e-18
c2245 n166__vddio vss 104.102e-18
c2246 n167__vddio vss 135.426e-18
c2247 n168__vddio vss 103.274e-18
c2248 n1071__vddio vss 57.9992e-18
c2249 n171__i0__i14__net1 vss 35.9038e-18
c2250 n299__chipdriverout vss 121.396e-18
c2251 n300__chipdriverout vss 104.528e-18
c2252 n301__chipdriverout vss 119.504e-18
c2253 n302__chipdriverout vss 104.528e-18
c2254 n303__chipdriverout vss 72.4607e-18
c2255 n304__chipdriverout vss 115.221e-18
c2256 n305__chipdriverout vss 104.268e-18
c2257 n306__chipdriverout vss 119.21e-18
c2258 n307__chipdriverout vss 104.268e-18
c2259 n308__chipdriverout vss 121.699e-18
c2260 n309__chipdriverout vss 104.268e-18
c2261 n310__chipdriverout vss 135.547e-18
c2262 n311__chipdriverout vss 103.704e-18
c2263 n167__i0__i14__net1 vss 38.0374e-18
c2264 n141__vddio vss 103.888e-18
c2265 n142__vddio vss 135.755e-18
c2266 n143__vddio vss 104.543e-18
c2267 n144__vddio vss 105.831e-18
c2268 n145__vddio vss 104.543e-18
c2269 n146__vddio vss 135.755e-18
c2270 n147__vddio vss 103.718e-18
c2271 n1072__vddio vss 58.0273e-18
c2272 n155__i0__i14__net1 vss 35.8431e-18
c2273 n260__chipdriverout vss 121.455e-18
c2274 n261__chipdriverout vss 104.528e-18
c2275 n262__chipdriverout vss 119.504e-18
c2276 n263__chipdriverout vss 104.528e-18
c2277 n264__chipdriverout vss 72.4607e-18
c2278 n265__chipdriverout vss 115.125e-18
c2279 n266__chipdriverout vss 104.411e-18
c2280 n267__chipdriverout vss 119.381e-18
c2281 n268__chipdriverout vss 104.411e-18
c2282 n269__chipdriverout vss 121.727e-18
c2283 n270__chipdriverout vss 104.411e-18
c2284 n271__chipdriverout vss 135.604e-18
c2285 n272__chipdriverout vss 103.874e-18
c2286 n151__i0__i14__net1 vss 38.0374e-18
c2287 n120__vddio vss 104.032e-18
c2288 n121__vddio vss 135.879e-18
c2289 n122__vddio vss 104.694e-18
c2290 n123__vddio vss 105.982e-18
c2291 n124__vddio vss 104.694e-18
c2292 n125__vddio vss 135.879e-18
c2293 n126__vddio vss 103.869e-18
c2294 n1073__vddio vss 81.1364e-18
c2295 n139__i0__i14__net1 vss 35.7866e-18
c2296 n221__chipdriverout vss 122.514e-18
c2297 n222__chipdriverout vss 105.748e-18
c2298 n223__chipdriverout vss 120.925e-18
c2299 n224__chipdriverout vss 105.748e-18
c2300 n225__chipdriverout vss 73.091e-18
c2301 n226__chipdriverout vss 115.567e-18
c2302 n227__chipdriverout vss 106.376e-18
c2303 n228__chipdriverout vss 121.714e-18
c2304 n229__chipdriverout vss 106.376e-18
c2305 n230__chipdriverout vss 123.75e-18
c2306 n231__chipdriverout vss 106.376e-18
c2307 n232__chipdriverout vss 137.982e-18
c2308 n233__chipdriverout vss 105.725e-18
c2309 n135__i0__i14__net1 vss 36.1638e-18
c2310 n99__vddio vss 103.476e-18
c2311 n100__vddio vss 135.286e-18
c2312 n101__vddio vss 104.019e-18
c2313 n102__vddio vss 105.31e-18
c2314 n103__vddio vss 104.019e-18
c2315 n104__vddio vss 135.286e-18
c2316 n105__vddio vss 103.197e-18
c2317 n1074__vddio vss 57.9417e-18
c2318 n123__i0__i14__net1 vss 35.7297e-18
c2319 n182__chipdriverout vss 120.807e-18
c2320 n183__chipdriverout vss 103.989e-18
c2321 n184__chipdriverout vss 119.095e-18
c2322 n185__chipdriverout vss 103.989e-18
c2323 n186__chipdriverout vss 72.0017e-18
c2324 n187__chipdriverout vss 114.411e-18
c2325 n188__chipdriverout vss 103.927e-18
c2326 n189__chipdriverout vss 118.961e-18
c2327 n190__chipdriverout vss 103.927e-18
c2328 n191__chipdriverout vss 121.31e-18
c2329 n192__chipdriverout vss 103.927e-18
c2330 n193__chipdriverout vss 135.254e-18
c2331 n194__chipdriverout vss 103.352e-18
c2332 n119__i0__i14__net1 vss 37.2153e-18
c2333 n78__vddio vss 103.662e-18
c2334 n79__vddio vss 135.873e-18
c2335 n80__vddio vss 104.437e-18
c2336 n81__vddio vss 105.72e-18
c2337 n82__vddio vss 104.437e-18
c2338 n83__vddio vss 135.873e-18
c2339 n84__vddio vss 103.612e-18
c2340 n1075__vddio vss 57.7881e-18
c2341 n107__i0__i14__net1 vss 36.2082e-18
c2342 n143__chipdriverout vss 119.274e-18
c2343 n144__chipdriverout vss 102.402e-18
c2344 n145__chipdriverout vss 117.256e-18
c2345 n146__chipdriverout vss 102.402e-18
c2346 n147__chipdriverout vss 70.8748e-18
c2347 n148__chipdriverout vss 112.671e-18
c2348 n149__chipdriverout vss 102.548e-18
c2349 n150__chipdriverout vss 117.314e-18
c2350 n151__chipdriverout vss 102.548e-18
c2351 n152__chipdriverout vss 119.936e-18
c2352 n153__chipdriverout vss 102.548e-18
c2353 n154__chipdriverout vss 133.626e-18
c2354 n155__chipdriverout vss 102.047e-18
c2355 n103__i0__i14__net1 vss 35.493e-18
c2356 n57__vddio vss 103.898e-18
c2357 n58__vddio vss 135.755e-18
c2358 n59__vddio vss 104.543e-18
c2359 n60__vddio vss 105.831e-18
c2360 n61__vddio vss 104.543e-18
c2361 n62__vddio vss 135.755e-18
c2362 n63__vddio vss 103.718e-18
c2363 n1076__vddio vss 58.0379e-18
c2364 n91__i0__i14__net1 vss 35.5021e-18
c2365 n104__chipdriverout vss 121.116e-18
c2366 n105__chipdriverout vss 104.376e-18
c2367 n106__chipdriverout vss 119.435e-18
c2368 n107__chipdriverout vss 104.376e-18
c2369 n108__chipdriverout vss 72.4167e-18
c2370 n109__chipdriverout vss 114.7e-18
c2371 n110__chipdriverout vss 104.534e-18
c2372 n111__chipdriverout vss 119.504e-18
c2373 n112__chipdriverout vss 104.534e-18
c2374 n113__chipdriverout vss 122e-18
c2375 n114__chipdriverout vss 104.534e-18
c2376 n115__chipdriverout vss 135.876e-18
c2377 n116__chipdriverout vss 103.933e-18
c2378 n87__i0__i14__net1 vss 36.5514e-18
c2379 n36__vddio vss 103.862e-18
c2380 n37__vddio vss 135.755e-18
c2381 n38__vddio vss 104.543e-18
c2382 n39__vddio vss 105.831e-18
c2383 n40__vddio vss 104.543e-18
c2384 n41__vddio vss 135.755e-18
c2385 n42__vddio vss 103.718e-18
c2386 n1077__vddio vss 81.2816e-18
c2387 n75__i0__i14__net1 vss 36.0622e-18
c2388 n65__chipdriverout vss 123.02e-18
c2389 n66__chipdriverout vss 104.376e-18
c2390 n67__chipdriverout vss 121.967e-18
c2391 n68__chipdriverout vss 104.376e-18
c2392 n69__chipdriverout vss 73.8554e-18
c2393 n70__chipdriverout vss 116.659e-18
c2394 n71__chipdriverout vss 106.761e-18
c2395 n72__chipdriverout vss 119.504e-18
c2396 n73__chipdriverout vss 104.534e-18
c2397 n74__chipdriverout vss 124.283e-18
c2398 n75__chipdriverout vss 104.534e-18
c2399 n76__chipdriverout vss 138.439e-18
c2400 n77__chipdriverout vss 104.14e-18
c2401 n69__i0__i14__net1 vss 38.4738e-18
c2402 n15__vddio vss 72.821e-18
c2403 n16__vddio vss 104.932e-18
c2404 n17__vddio vss 73.553e-18
c2405 n18__vddio vss 74.4496e-18
c2406 n19__vddio vss 73.553e-18
c2407 n20__vddio vss 104.932e-18
c2408 n21__vddio vss 73.0564e-18
c2409 n63__i0__i14__net1 vss 59.712e-18
c2410 n26__chipdriverout vss 51.6966e-18
c2411 n27__chipdriverout vss 38.1361e-18
c2412 n28__chipdriverout vss 37.3503e-18
c2413 n29__chipdriverout vss 38.1752e-18
c2414 n30__chipdriverout vss 37.2255e-18
c2415 n31__chipdriverout vss 60.3366e-18
c2416 n32__chipdriverout vss 34.591e-18
c2417 n33__chipdriverout vss 40.718e-18
c2418 n34__chipdriverout vss 37.866e-18
c2419 n35__chipdriverout vss 43.1922e-18
c2420 n36__chipdriverout vss 38.0054e-18
c2421 n37__chipdriverout vss 45.5469e-18
c2422 n38__chipdriverout vss 47.9731e-18
c2423 n17__pinout vss 91.1443e-18
c2424 n11__i0__i11__outinv vss 231.536e-18
c2425 n16__pinout vss 65.176e-18
c2426 n21__i0__net4 vss 295.543e-18
c2427 n10__i0__i11__outinv vss 99.0172e-18
c2428 n15__pinout vss 89.4661e-18
c2429 n18__i0__net4 vss 68.5272e-18
c2430 n32__pinin vss 85.0995e-18
c2431 n17__i0__net4 vss 127.226e-18
c2432 n31__pinin vss 72.0512e-18
c2433 n7__i0__i11__outinv vss 282.281e-18
c2434 n30__pinin vss 76.4335e-18
c2435 n15__i0__net4 vss 51.5842e-18
c2436 n16__i0__net4 vss 117.605e-18
c2437 n61__i0__i12__net1 vss 302.612e-18
c2438 n60__i0__i12__net1 vss 274.539e-18
c2439 n13__i0__net4 vss 47.6535e-18
c2440 n14__i0__net4 vss 75.2722e-18
c2441 n78__i0__net3 vss 258.983e-18
c2442 n76__i0__net3 vss 206.896e-18
c2443 n49__i0__i12__net1 vss 56.8462e-18
c2444 n50__i0__i12__net1 vss 37.8272e-18
c2445 n41__i0__i12__net1 vss 55.2948e-18
c2446 n42__i0__i12__net1 vss 31.798e-18
c2447 n71__i0__net3 vss 211.653e-18
c2448 n67__i0__net3 vss 254.473e-18
c2449 n39__i0__i12__net1 vss 58.8338e-18
c2450 n40__i0__i12__net1 vss 34.6704e-18
c2451 n37__i0__i12__net1 vss 59.1284e-18
c2452 n38__i0__i12__net1 vss 37.5689e-18
c2453 n58__i0__net3 vss 273.089e-18
c2454 n64__i0__net3 vss 223.578e-18
c2455 n33__i0__i12__net1 vss 57.4787e-18
c2456 n34__i0__i12__net1 vss 32.0308e-18
c2457 n29__i0__i12__net1 vss 75.2304e-18
c2458 n30__i0__i12__net1 vss 40.5938e-18
c2459 n49__i0__net3 vss 212.548e-18
c2460 n54__i0__net3 vss 208.469e-18
c2461 n1642__vddio vss 178.16e-18
c2462 n1640__vddio vss 159.674e-18
c2463 n1637__vddio vss 104.043e-18
c2464 n1636__vddio vss 74.7115e-18
c2465 n45__i0__net3 vss 64.5786e-18
c2466 n46__i0__net3 vss 47.3787e-18
c2467 n209__i0__i13__net1 vss 264.146e-18
c2468 n211__i0__i13__net1 vss 331.919e-18
c2469 n217__i0__i13__net1 vss 245.208e-18
c2470 n216__i0__i13__net1 vss 282.692e-18
c2471 n213__i0__i13__net1 vss 304.961e-18
c2472 n41__i0__net3 vss 61.4663e-18
c2473 n42__i0__net3 vss 40.8834e-18
c2474 n1629__vddio vss 259.751e-18
c2475 n1632__vddio vss 351.358e-18
c2476 n1634__vddio vss 257.836e-18
c2477 n1635__vddio vss 154.796e-18
c2478 n198__i0__i13__net1 vss 283.652e-18
c2479 n200__i0__i13__net1 vss 349.051e-18
c2480 n206__i0__i13__net1 vss 260.378e-18
c2481 n205__i0__i13__net1 vss 297.984e-18
c2482 n202__i0__i13__net1 vss 330.783e-18
c2483 n31__i0__net3 vss 61.612e-18
c2484 n32__i0__net3 vss 41.0078e-18
c2485 n1622__vddio vss 267.849e-18
c2486 n1625__vddio vss 352.965e-18
c2487 n1627__vddio vss 257.775e-18
c2488 n1628__vddio vss 153.869e-18
c2489 n29__i0__net3 vss 61.9264e-18
c2490 n30__i0__net3 vss 40.0936e-18
c2491 n187__i0__i13__net1 vss 282.697e-18
c2492 n189__i0__i13__net1 vss 342.167e-18
c2493 n195__i0__i13__net1 vss 259.669e-18
c2494 n194__i0__i13__net1 vss 297.475e-18
c2495 n191__i0__i13__net1 vss 315.63e-18
c2496 n25__i0__net3 vss 74.9614e-18
c2497 n26__i0__net3 vss 48.4216e-18
c2498 n1621__vddio vss 202.828e-18
c2499 n1619__vddio vss 296.51e-18
c2500 n1616__vddio vss 233.486e-18
c2501 n1615__vddio vss 142.909e-18
c2502 n1697__vddio vss 20.3159e-18
c2503 n1608__vddio vss 173.141e-18
c2504 n1611__vddio vss 198.271e-18
c2505 n1613__vddio vss 146.579e-18
c2506 n1614__vddio vss 85.7912e-18
c2507 n165__i0__i13__net1 vss 43.6356e-18
c2508 n166__i0__i13__net1 vss 35.6047e-18
c2509 n325__i0__net2 vss 277.881e-18
c2510 n326__i0__net2 vss 279.37e-18
c2511 n329__i0__net2 vss 309.21e-18
c2512 n322__i0__net2 vss 268.375e-18
c2513 n324__i0__net2 vss 314.093e-18
c2514 n161__i0__i13__net1 vss 64.4989e-18
c2515 n162__i0__i13__net1 vss 36.1322e-18
c2516 n1601__vddio vss 268.195e-18
c2517 n1604__vddio vss 356.71e-18
c2518 n1606__vddio vss 257.083e-18
c2519 n1607__vddio vss 158.276e-18
c2520 n157__i0__i13__net1 vss 54.5687e-18
c2521 n158__i0__i13__net1 vss 35.2125e-18
c2522 n316__i0__net2 vss 296.895e-18
c2523 n317__i0__net2 vss 297.025e-18
c2524 n320__i0__net2 vss 332.696e-18
c2525 n313__i0__net2 vss 293.503e-18
c2526 n315__i0__net2 vss 340.988e-18
c2527 n151__i0__i13__net1 vss 64.592e-18
c2528 n152__i0__i13__net1 vss 36.2796e-18
c2529 n1594__vddio vss 271.633e-18
c2530 n1597__vddio vss 357.916e-18
c2531 n1599__vddio vss 259.161e-18
c2532 n1600__vddio vss 153.344e-18
c2533 n149__i0__i13__net1 vss 54.5687e-18
c2534 n150__i0__i13__net1 vss 36.003e-18
c2535 n309__i0__net2 vss 292.746e-18
c2536 n311__i0__net2 vss 341.825e-18
c2537 n303__i0__net2 vss 301.538e-18
c2538 n304__i0__net2 vss 302.826e-18
c2539 n307__i0__net2 vss 332.621e-18
c2540 n1587__vddio vss 270.366e-18
c2541 n1590__vddio vss 359.924e-18
c2542 n1592__vddio vss 258.914e-18
c2543 n1593__vddio vss 116.031e-18
c2544 n141__i0__i13__net1 vss 64.8415e-18
c2545 n142__i0__i13__net1 vss 36.003e-18
c2546 n300__i0__net2 vss 291.947e-18
c2547 n302__i0__net2 vss 349.014e-18
c2548 n294__i0__net2 vss 301.034e-18
c2549 n295__i0__net2 vss 302.301e-18
c2550 n298__i0__net2 vss 333.493e-18
c2551 n137__i0__i13__net1 vss 64.0864e-18
c2552 n138__i0__i13__net1 vss 36.216e-18
c2553 n1580__vddio vss 266.981e-18
c2554 n1583__vddio vss 358.718e-18
c2555 n1585__vddio vss 261.233e-18
c2556 n1586__vddio vss 156.508e-18
c2557 n133__i0__i13__net1 vss 64.7226e-18
c2558 n134__i0__i13__net1 vss 35.2125e-18
c2559 n291__i0__net2 vss 287.382e-18
c2560 n293__i0__net2 vss 346.245e-18
c2561 n285__i0__net2 vss 296.366e-18
c2562 n286__i0__net2 vss 296.499e-18
c2563 n289__i0__net2 vss 328.364e-18
c2564 n129__i0__i13__net1 vss 41.3887e-18
c2565 n130__i0__i13__net1 vss 53.2787e-18
c2566 n1573__vddio vss 268.195e-18
c2567 n1576__vddio vss 356.71e-18
c2568 n1578__vddio vss 257.043e-18
c2569 n1579__vddio vss 154.816e-18
c2570 n125__i0__i13__net1 vss 64.7226e-18
c2571 n126__i0__i13__net1 vss 35.2125e-18
c2572 n282__i0__net2 vss 286.596e-18
c2573 n284__i0__net2 vss 346.499e-18
c2574 n276__i0__net2 vss 296.895e-18
c2575 n277__i0__net2 vss 297.025e-18
c2576 n280__i0__net2 vss 333.51e-18
c2577 n117__i0__i13__net1 vss 63.7843e-18
c2578 n118__i0__i13__net1 vss 36.2796e-18
c2579 n1572__vddio vss 271.182e-18
c2580 n1570__vddio vss 356.996e-18
c2581 n1567__vddio vss 254.574e-18
c2582 n1566__vddio vss 167.57e-18
c2583 n113__i0__i13__net1 vss 63.1763e-18
c2584 n114__i0__i13__net1 vss 36.003e-18
c2585 n273__i0__net2 vss 288.593e-18
c2586 n275__i0__net2 vss 345.695e-18
c2587 n267__i0__net2 vss 301.928e-18
c2588 n268__i0__net2 vss 303.151e-18
c2589 n271__i0__net2 vss 330.279e-18
c2590 n1702__vddio vss 20.8697e-18
c2591 n1559__vddio vss 266.981e-18
c2592 n1562__vddio vss 358.718e-18
c2593 n1564__vddio vss 261.232e-18
c2594 n1565__vddio vss 155.557e-18
c2595 n264__i0__net2 vss 287.376e-18
c2596 n266__i0__net2 vss 346.245e-18
c2597 n258__i0__net2 vss 296.366e-18
c2598 n259__i0__net2 vss 296.499e-18
c2599 n262__i0__net2 vss 327.488e-18
c2600 n97__i0__i13__net1 vss 41.3977e-18
c2601 n98__i0__i13__net1 vss 53.2877e-18
c2602 n1552__vddio vss 265.258e-18
c2603 n1555__vddio vss 354.87e-18
c2604 n1557__vddio vss 256.439e-18
c2605 n1558__vddio vss 154.452e-18
c2606 n89__i0__i13__net1 vss 65.251e-18
c2607 n90__i0__i13__net1 vss 35.1223e-18
c2608 n255__i0__net2 vss 288.217e-18
c2609 n257__i0__net2 vss 346.559e-18
c2610 n249__i0__net2 vss 299.037e-18
c2611 n250__i0__net2 vss 299.019e-18
c2612 n253__i0__net2 vss 328.729e-18
c2613 n85__i0__i13__net1 vss 63.8313e-18
c2614 n86__i0__i13__net1 vss 37.0075e-18
c2615 n1545__vddio vss 271.098e-18
c2616 n1548__vddio vss 362.867e-18
c2617 n1550__vddio vss 262.298e-18
c2618 n1551__vddio vss 115.031e-18
c2619 n73__i0__i13__net1 vss 63.6958e-18
c2620 n74__i0__i13__net1 vss 35.2856e-18
c2621 n244__i0__net2 vss 297.591e-18
c2622 n245__i0__net2 vss 299.151e-18
c2623 n248__i0__net2 vss 330.222e-18
c2624 n241__i0__net2 vss 287.963e-18
c2625 n243__i0__net2 vss 345.626e-18
c2626 n69__i0__i13__net1 vss 64.1064e-18
c2627 n70__i0__i13__net1 vss 36.0816e-18
c2628 n1538__vddio vss 256.463e-18
c2629 n1541__vddio vss 340.065e-18
c2630 n1543__vddio vss 246.02e-18
c2631 n1544__vddio vss 140.243e-18
c2632 n57__i0__i13__net1 vss 78.1887e-18
c2633 n58__i0__i13__net1 vss 43.4997e-18
c2634 n237__i0__net2 vss 151.664e-18
c2635 n239__i0__net2 vss 185.249e-18
c2636 n231__i0__net2 vss 149.235e-18
c2637 n232__i0__net2 vss 147.402e-18
c2638 n235__i0__net2 vss 187.96e-18
c2639 n1396__vddio vss 2.15414e-18
c2640 n1374__vddio vss 192.28e-18
c2641 n1377__vddio vss 148.087e-18
c2642 n1378__vddio vss 93.5287e-18
c2643 n1380__vddio vss 136.583e-18
c2644 n1381__vddio vss 80.4788e-18
c2645 n1383__vddio vss 130.2e-18
c2646 n1384__vddio vss 79.6843e-18
c2647 n1386__vddio vss 112.456e-18
c2648 n1288__i0__i14__net1 vss 132.07e-18
c2649 n1289__i0__i14__net1 vss 225.494e-18
c2650 n1291__i0__i14__net1 vss 194.491e-18
c2651 n1292__i0__i14__net1 vss 238.01e-18
c2652 n1294__i0__i14__net1 vss 281.012e-18
c2653 n1297__i0__i14__net1 vss 232.096e-18
c2654 n1300__i0__i14__net1 vss 205.848e-18
c2655 n1301__i0__i14__net1 vss 230.086e-18
c2656 n1303__i0__i14__net1 vss 199.109e-18
c2657 n1304__i0__i14__net1 vss 203.836e-18
c2658 n1306__i0__i14__net1 vss 193.557e-18
c2659 n1307__i0__i14__net1 vss 204.775e-18
c2660 n1309__i0__i14__net1 vss 248.816e-18
c2661 n217__i0__net2 vss 43.727e-18
c2662 n218__i0__net2 vss 37.3034e-18
c2663 n1353__vddio vss 290.989e-18
c2664 n1356__vddio vss 242.684e-18
c2665 n1357__vddio vss 152.929e-18
c2666 n1359__vddio vss 263.97e-18
c2667 n1360__vddio vss 158.762e-18
c2668 n1362__vddio vss 243.408e-18
c2669 n1363__vddio vss 157.198e-18
c2670 n1365__vddio vss 247.984e-18
c2671 n213__i0__net2 vss 39.3966e-18
c2672 n214__i0__net2 vss 49.4087e-18
c2673 n1249__i0__i14__net1 vss 129.353e-18
c2674 n1250__i0__i14__net1 vss 220.178e-18
c2675 n1252__i0__i14__net1 vss 189.327e-18
c2676 n1253__i0__i14__net1 vss 225.493e-18
c2677 n1255__i0__i14__net1 vss 267.354e-18
c2678 n1258__i0__i14__net1 vss 232.372e-18
c2679 n1261__i0__i14__net1 vss 194.452e-18
c2680 n1262__i0__i14__net1 vss 218.572e-18
c2681 n1264__i0__i14__net1 vss 196.457e-18
c2682 n1265__i0__i14__net1 vss 205.649e-18
c2683 n1267__i0__i14__net1 vss 191.052e-18
c2684 n1268__i0__i14__net1 vss 206.301e-18
c2685 n1270__i0__i14__net1 vss 245.994e-18
c2686 n209__i0__net2 vss 43.7536e-18
c2687 n210__i0__net2 vss 38.9608e-18
c2688 n1398__vddio vss 5.73143e-18
c2689 n1332__vddio vss 286.449e-18
c2690 n1335__vddio vss 239.433e-18
c2691 n1336__vddio vss 152.076e-18
c2692 n1338__vddio vss 260.078e-18
c2693 n1339__vddio vss 157.286e-18
c2694 n1341__vddio vss 239.433e-18
c2695 n1342__vddio vss 156.106e-18
c2696 n1344__vddio vss 188.864e-18
c2697 n205__i0__net2 vss 39.3966e-18
c2698 n206__i0__net2 vss 48.001e-18
c2699 n1226__i0__i14__net1 vss 220.178e-18
c2700 n1228__i0__i14__net1 vss 189.327e-18
c2701 n1229__i0__i14__net1 vss 225.493e-18
c2702 n1231__i0__i14__net1 vss 267.354e-18
c2703 n1208__i0__i14__net1 vss 236.001e-18
c2704 n1211__i0__i14__net1 vss 200.646e-18
c2705 n1212__i0__i14__net1 vss 226.765e-18
c2706 n1214__i0__i14__net1 vss 202.794e-18
c2707 n1215__i0__i14__net1 vss 213.904e-18
c2708 n1217__i0__i14__net1 vss 197.143e-18
c2709 n1218__i0__i14__net1 vss 214.736e-18
c2710 n1220__i0__i14__net1 vss 249.704e-18
c2711 n201__i0__net2 vss 43.7536e-18
c2712 n202__i0__net2 vss 37.5548e-18
c2713 n1311__vddio vss 284.183e-18
c2714 n1314__vddio vss 237.352e-18
c2715 n1315__vddio vss 150.74e-18
c2716 n1317__vddio vss 257.742e-18
c2717 n1318__vddio vss 155.962e-18
c2718 n1320__vddio vss 237.352e-18
c2719 n1321__vddio vss 154.717e-18
c2720 n1323__vddio vss 186.586e-18
c2721 n1186__i0__i14__net1 vss 129.353e-18
c2722 n1187__i0__i14__net1 vss 220.178e-18
c2723 n1189__i0__i14__net1 vss 189.327e-18
c2724 n1190__i0__i14__net1 vss 225.493e-18
c2725 n1192__i0__i14__net1 vss 267.354e-18
c2726 n1169__i0__i14__net1 vss 232.823e-18
c2727 n1172__i0__i14__net1 vss 197.977e-18
c2728 n1173__i0__i14__net1 vss 224.089e-18
c2729 n1175__i0__i14__net1 vss 200.208e-18
c2730 n1176__i0__i14__net1 vss 211.084e-18
c2731 n1178__i0__i14__net1 vss 194.541e-18
c2732 n1179__i0__i14__net1 vss 212.115e-18
c2733 n1181__i0__i14__net1 vss 249.843e-18
c2734 n193__i0__net2 vss 43.736e-18
c2735 n194__i0__net2 vss 35.9068e-18
c2736 n1290__vddio vss 290.6e-18
c2737 n1293__vddio vss 240.56e-18
c2738 n1294__vddio vss 151.558e-18
c2739 n1296__vddio vss 260.913e-18
c2740 n1297__vddio vss 157.025e-18
c2741 n1299__vddio vss 240.56e-18
c2742 n1300__vddio vss 155.434e-18
c2743 n1302__vddio vss 186.748e-18
c2744 n189__i0__net2 vss 39.3558e-18
c2745 n190__i0__net2 vss 49.2159e-18
c2746 n1132__i0__i14__net1 vss 129.353e-18
c2747 n1133__i0__i14__net1 vss 220.178e-18
c2748 n1135__i0__i14__net1 vss 189.327e-18
c2749 n1136__i0__i14__net1 vss 225.493e-18
c2750 n1138__i0__i14__net1 vss 267.362e-18
c2751 n1141__i0__i14__net1 vss 229.109e-18
c2752 n1144__i0__i14__net1 vss 191.818e-18
c2753 n1145__i0__i14__net1 vss 215.836e-18
c2754 n1147__i0__i14__net1 vss 193.914e-18
c2755 n1148__i0__i14__net1 vss 202.754e-18
c2756 n1150__i0__i14__net1 vss 188.491e-18
c2757 n1151__i0__i14__net1 vss 203.621e-18
c2758 n1153__i0__i14__net1 vss 242.768e-18
c2759 n185__i0__net2 vss 30.2727e-18
c2760 n186__i0__net2 vss 24.6473e-18
c2761 n1269__vddio vss 276.874e-18
c2762 n1272__vddio vss 242.582e-18
c2763 n1273__vddio vss 152.866e-18
c2764 n1275__vddio vss 263.174e-18
c2765 n1276__vddio vss 158.319e-18
c2766 n1278__vddio vss 242.582e-18
c2767 n1279__vddio vss 156.794e-18
c2768 n1281__vddio vss 246.975e-18
c2769 n181__i0__net2 vss 39.3729e-18
c2770 n182__i0__net2 vss 49.2334e-18
c2771 n1094__i0__i14__net1 vss 220.178e-18
c2772 n1096__i0__i14__net1 vss 189.327e-18
c2773 n1097__i0__i14__net1 vss 225.493e-18
c2774 n1099__i0__i14__net1 vss 267.362e-18
c2775 n1102__i0__i14__net1 vss 232.382e-18
c2776 n1105__i0__i14__net1 vss 194.452e-18
c2777 n1106__i0__i14__net1 vss 218.572e-18
c2778 n1108__i0__i14__net1 vss 196.457e-18
c2779 n1109__i0__i14__net1 vss 205.649e-18
c2780 n1111__i0__i14__net1 vss 191.052e-18
c2781 n1112__i0__i14__net1 vss 206.301e-18
c2782 n1114__i0__i14__net1 vss 246.013e-18
c2783 n173__i0__net2 vss 30.2727e-18
c2784 n174__i0__net2 vss 38.9975e-18
c2785 n1400__vddio vss 5.92561e-18
c2786 n1248__vddio vss 286.064e-18
c2787 n1251__vddio vss 239.433e-18
c2788 n1252__vddio vss 152.076e-18
c2789 n1254__vddio vss 260.078e-18
c2790 n1255__vddio vss 157.286e-18
c2791 n1257__vddio vss 239.433e-18
c2792 n1258__vddio vss 156.106e-18
c2793 n1260__vddio vss 189.189e-18
c2794 n167__i0__net2 vss 39.3729e-18
c2795 n168__i0__net2 vss 47.8258e-18
c2796 n1069__i0__i14__net1 vss 129.353e-18
c2797 n1070__i0__i14__net1 vss 220.178e-18
c2798 n1072__i0__i14__net1 vss 189.327e-18
c2799 n1073__i0__i14__net1 vss 225.493e-18
c2800 n1075__i0__i14__net1 vss 267.362e-18
c2801 n1052__i0__i14__net1 vss 236.017e-18
c2802 n1055__i0__i14__net1 vss 200.646e-18
c2803 n1056__i0__i14__net1 vss 226.765e-18
c2804 n1058__i0__i14__net1 vss 202.794e-18
c2805 n1059__i0__i14__net1 vss 213.904e-18
c2806 n1061__i0__i14__net1 vss 197.143e-18
c2807 n1062__i0__i14__net1 vss 214.736e-18
c2808 n1064__i0__i14__net1 vss 251.688e-18
c2809 n165__i0__net2 vss 30.2727e-18
c2810 n166__i0__net2 vss 37.5915e-18
c2811 n1226__vddio vss 283.738e-18
c2812 n1229__vddio vss 237.352e-18
c2813 n1230__vddio vss 150.679e-18
c2814 n1233__vddio vss 257.682e-18
c2815 n1234__vddio vss 155.902e-18
c2816 n1237__vddio vss 237.352e-18
c2817 n1238__vddio vss 154.657e-18
c2818 n1246__vddio vss 186.7e-18
c2819 n1030__i0__i14__net1 vss 135.595e-18
c2820 n1031__i0__i14__net1 vss 226.396e-18
c2821 n1033__i0__i14__net1 vss 194.632e-18
c2822 n1034__i0__i14__net1 vss 231.97e-18
c2823 n1036__i0__i14__net1 vss 271.337e-18
c2824 n1013__i0__i14__net1 vss 236.941e-18
c2825 n1016__i0__i14__net1 vss 202.79e-18
c2826 n1017__i0__i14__net1 vss 230.061e-18
c2827 n1019__i0__i14__net1 vss 205.201e-18
c2828 n1020__i0__i14__net1 vss 216.955e-18
c2829 n1022__i0__i14__net1 vss 199.287e-18
c2830 n1023__i0__i14__net1 vss 218.269e-18
c2831 n1025__i0__i14__net1 vss 257.112e-18
c2832 n157__i0__net2 vss 45.467e-18
c2833 n158__i0__net2 vss 37.5756e-18
c2834 n1206__vddio vss 286.78e-18
c2835 n1209__vddio vss 240.071e-18
c2836 n1210__vddio vss 150.931e-18
c2837 n1212__vddio vss 259.699e-18
c2838 n1213__vddio vss 156.567e-18
c2839 n1215__vddio vss 240.071e-18
c2840 n1216__vddio vss 154.764e-18
c2841 n1218__vddio vss 186.153e-18
c2842 n145__i0__net2 vss 39.5294e-18
c2843 n146__i0__net2 vss 48.977e-18
c2844 n977__i0__i14__net1 vss 232.108e-18
c2845 n979__i0__i14__net1 vss 198.944e-18
c2846 n980__i0__i14__net1 vss 237.55e-18
c2847 n982__i0__i14__net1 vss 276.378e-18
c2848 n985__i0__i14__net1 vss 232.037e-18
c2849 n988__i0__i14__net1 vss 196.041e-18
c2850 n989__i0__i14__net1 vss 220.162e-18
c2851 n991__i0__i14__net1 vss 198.062e-18
c2852 n992__i0__i14__net1 vss 207.137e-18
c2853 n994__i0__i14__net1 vss 192.641e-18
c2854 n995__i0__i14__net1 vss 207.778e-18
c2855 n997__i0__i14__net1 vss 246.568e-18
c2856 n141__i0__net2 vss 42.7209e-18
c2857 n142__i0__net2 vss 39.0021e-18
c2858 n1185__vddio vss 290.429e-18
c2859 n1188__vddio vss 242.522e-18
c2860 n1189__vddio vss 152.838e-18
c2861 n1191__vddio vss 263.118e-18
c2862 n1192__vddio vss 158.288e-18
c2863 n1194__vddio vss 242.522e-18
c2864 n1195__vddio vss 156.767e-18
c2865 n1197__vddio vss 246.795e-18
c2866 n129__i0__net2 vss 39.5294e-18
c2867 n130__i0__net2 vss 47.3361e-18
c2868 n937__i0__i14__net1 vss 136.713e-18
c2869 n938__i0__i14__net1 vss 232.169e-18
c2870 n940__i0__i14__net1 vss 199.005e-18
c2871 n941__i0__i14__net1 vss 237.611e-18
c2872 n943__i0__i14__net1 vss 276.438e-18
c2873 n946__i0__i14__net1 vss 227.769e-18
c2874 n949__i0__i14__net1 vss 192.393e-18
c2875 n950__i0__i14__net1 vss 216.412e-18
c2876 n952__i0__i14__net1 vss 194.504e-18
c2877 n953__i0__i14__net1 vss 203.247e-18
c2878 n955__i0__i14__net1 vss 189.065e-18
c2879 n956__i0__i14__net1 vss 204.104e-18
c2880 n958__i0__i14__net1 vss 243.093e-18
c2881 n125__i0__net2 vss 42.7209e-18
c2882 n126__i0__net2 vss 39.0021e-18
c2883 n1402__vddio vss 5.58211e-18
c2884 n1164__vddio vss 288.258e-18
c2885 n1167__vddio vss 240.501e-18
c2886 n1168__vddio vss 151.531e-18
c2887 n1170__vddio vss 260.858e-18
c2888 n1171__vddio vss 156.993e-18
c2889 n1173__vddio vss 240.501e-18
c2890 n1174__vddio vss 155.407e-18
c2891 n1176__vddio vss 186.813e-18
c2892 n113__i0__net2 vss 39.5294e-18
c2893 n114__i0__net2 vss 45.8986e-18
c2894 n898__i0__i14__net1 vss 136.713e-18
c2895 n899__i0__i14__net1 vss 232.169e-18
c2896 n901__i0__i14__net1 vss 199.005e-18
c2897 n902__i0__i14__net1 vss 237.611e-18
c2898 n904__i0__i14__net1 vss 276.438e-18
c2899 n907__i0__i14__net1 vss 230.978e-18
c2900 n910__i0__i14__net1 vss 196.017e-18
c2901 n911__i0__i14__net1 vss 221.539e-18
c2902 n913__i0__i14__net1 vss 198.269e-18
c2903 n914__i0__i14__net1 vss 208.38e-18
c2904 n916__i0__i14__net1 vss 192.58e-18
c2905 n917__i0__i14__net1 vss 209.423e-18
c2906 n919__i0__i14__net1 vss 246.503e-18
c2907 n109__i0__net2 vss 42.7209e-18
c2908 n110__i0__net2 vss 39.1794e-18
c2909 n1143__vddio vss 284.54e-18
c2910 n1146__vddio vss 238.224e-18
c2911 n1147__vddio vss 151.113e-18
c2912 n1149__vddio vss 258.503e-18
c2913 n1150__vddio vss 156.446e-18
c2914 n1152__vddio vss 238.224e-18
c2915 n1153__vddio vss 155.09e-18
c2916 n1155__vddio vss 186.359e-18
c2917 n2__pinout vss 70.1716e-18
c2918 n97__i0__net2 vss 46.7855e-18
c2919 n98__i0__net2 vss 38.0095e-18
c2920 n859__i0__i14__net1 vss 16.823e-18
c2921 n860__i0__i14__net1 vss 216.175e-18
c2922 n862__i0__i14__net1 vss 182.592e-18
c2923 n863__i0__i14__net1 vss 221.41e-18
c2924 n865__i0__i14__net1 vss 257.922e-18
c2925 n868__i0__i14__net1 vss 258.293e-18
c2926 n871__i0__i14__net1 vss 183.695e-18
c2927 n872__i0__i14__net1 vss 208.821e-18
c2928 n874__i0__i14__net1 vss 185.646e-18
c2929 n875__i0__i14__net1 vss 228.472e-18
c2930 n877__i0__i14__net1 vss 180.192e-18
c2931 n878__i0__i14__net1 vss 229.508e-18
c2932 n880__i0__i14__net1 vss 234.206e-18
c2933 n1122__vddio vss 270.939e-18
c2934 n1125__vddio vss 256.711e-18
c2935 n1126__vddio vss 136.477e-18
c2936 n1128__vddio vss 244.624e-18
c2937 n1129__vddio vss 141.594e-18
c2938 n1131__vddio vss 256.711e-18
c2939 n1132__vddio vss 140.522e-18
c2940 n1134__vddio vss 247.284e-18
c2941 n21__pinin vss 82.7197e-18
c2942 n81__i0__net2 vss 39.4886e-18
c2943 n82__i0__net2 vss 48.7843e-18
c2944 n820__i0__i14__net1 vss 153.021e-18
c2945 n821__i0__i14__net1 vss 216.175e-18
c2946 n823__i0__i14__net1 vss 182.592e-18
c2947 n824__i0__i14__net1 vss 221.41e-18
c2948 n826__i0__i14__net1 vss 276.438e-18
c2949 n829__i0__i14__net1 vss 232.037e-18
c2950 n832__i0__i14__net1 vss 180.062e-18
c2951 n833__i0__i14__net1 vss 203.741e-18
c2952 n835__i0__i14__net1 vss 198.122e-18
c2953 n836__i0__i14__net1 vss 207.137e-18
c2954 n838__i0__i14__net1 vss 192.702e-18
c2955 n839__i0__i14__net1 vss 207.778e-18
c2956 n841__i0__i14__net1 vss 245.124e-18
c2957 n77__i0__net2 vss 23.271e-18
c2958 n78__i0__net2 vss 47.5521e-18
c2959 n15__pinin vss 63.373e-18
c2960 n1101__vddio vss 291.05e-18
c2961 n1104__vddio vss 243.382e-18
c2962 n1105__vddio vss 153.255e-18
c2963 n1107__vddio vss 263.945e-18
c2964 n1108__vddio vss 158.748e-18
c2965 n1110__vddio vss 243.382e-18
c2966 n1111__vddio vss 157.186e-18
c2967 n1113__vddio vss 246.844e-18
c2968 n13__reset vss 49.6343e-18
c2969 n65__i0__net2 vss 39.4115e-18
c2970 n66__i0__net2 vss 47.0659e-18
c2971 n781__i0__i14__net1 vss 135.127e-18
c2972 n782__i0__i14__net1 vss 236.054e-18
c2973 n784__i0__i14__net1 vss 202.761e-18
c2974 n785__i0__i14__net1 vss 241.562e-18
c2975 n787__i0__i14__net1 vss 279.867e-18
c2976 n790__i0__i14__net1 vss 228.75e-18
c2977 n793__i0__i14__net1 vss 197.428e-18
c2978 n794__i0__i14__net1 vss 221.694e-18
c2979 n796__i0__i14__net1 vss 199.587e-18
c2980 n797__i0__i14__net1 vss 204.329e-18
c2981 n799__i0__i14__net1 vss 194.074e-18
c2982 n800__i0__i14__net1 vss 205.258e-18
c2983 n802__i0__i14__net1 vss 248.042e-18
c2984 n61__i0__net2 vss 40.417e-18
c2985 n62__i0__net2 vss 46.2852e-18
c2986 n26__i1__net1 vss 129.316e-18
c2987 n41__clk vss 90.7191e-18
c2988 n1080__vddio vss 163.541e-18
c2989 n1083__vddio vss 129.575e-18
c2990 n1084__vddio vss 91.8108e-18
c2991 n1086__vddio vss 151.752e-18
c2992 n1087__vddio vss 94.4575e-18
c2993 n1089__vddio vss 130.143e-18
c2994 n1090__vddio vss 93.0941e-18
c2995 n1092__vddio vss 107.02e-18
c2996 n38__clk vss 307.16e-18
c2997 n23__i1__net1 vss 327.514e-18
c2998 n14__i1__net7 vss 61.9781e-18
c2999 n6__i1__net7 vss 53.3952e-18
c3000 n1010__vddio vss 154.935e-18
c3001 n1013__vddio vss 131.362e-18
c3002 n1014__vddio vss 78.8374e-18
c3003 n1016__vddio vss 138.047e-18
c3004 n1017__vddio vss 81.6711e-18
c3005 n1019__vddio vss 131.362e-18
c3006 n1020__vddio vss 81.0225e-18
c3007 n1022__vddio vss 114.35e-18
c3008 n2__r0 vss 103.149e-18
c3009 n1904__chipdriverout vss 225.595e-18
c3010 n1906__chipdriverout vss 194.436e-18
c3011 n1907__chipdriverout vss 230.908e-18
c3012 n1909__chipdriverout vss 271.077e-18
c3013 n1886__chipdriverout vss 234.453e-18
c3014 n1889__chipdriverout vss 204.62e-18
c3015 n1890__chipdriverout vss 230.909e-18
c3016 n1892__chipdriverout vss 206.838e-18
c3017 n1893__chipdriverout vss 213.065e-18
c3018 n1895__chipdriverout vss 201.139e-18
c3019 n1896__chipdriverout vss 214.042e-18
c3020 n1898__chipdriverout vss 257.068e-18
c3021 n1407__vddio vss 6.9887e-18
c3022 n769__i0__i14__net1 vss 43.8728e-18
c3023 n770__i0__i14__net1 vss 37.482e-18
c3024 n42__s vss 57.0012e-18
c3025 n989__vddio vss 284.159e-18
c3026 n992__vddio vss 238.206e-18
c3027 n993__vddio vss 151.093e-18
c3028 n995__vddio vss 258.504e-18
c3029 n996__vddio vss 156.359e-18
c3030 n998__vddio vss 238.206e-18
c3031 n999__vddio vss 155.073e-18
c3032 n1001__vddio vss 187.67e-18
c3033 n9__i1__net6 vss 61.72e-18
c3034 n1864__chipdriverout vss 149.049e-18
c3035 n1865__chipdriverout vss 207.741e-18
c3036 n1867__chipdriverout vss 176.023e-18
c3037 n1868__chipdriverout vss 213.04e-18
c3038 n1870__chipdriverout vss 247.474e-18
c3039 n1847__chipdriverout vss 262.087e-18
c3040 n1850__chipdriverout vss 189.365e-18
c3041 n1851__chipdriverout vss 216.2e-18
c3042 n1853__chipdriverout vss 191.527e-18
c3043 n1854__chipdriverout vss 235.459e-18
c3044 n1856__chipdriverout vss 185.829e-18
c3045 n1857__chipdriverout vss 236.872e-18
c3046 n1859__chipdriverout vss 242.601e-18
c3047 n40__s vss 61.9641e-18
c3048 n968__vddio vss 266.553e-18
c3049 n969__vddio vss 267.101e-18
c3050 n972__vddio vss 141.433e-18
c3051 n973__vddio vss 255.214e-18
c3052 n976__vddio vss 146.967e-18
c3053 n977__vddio vss 267.101e-18
c3054 n980__vddio vss 145.468e-18
c3055 n987__vddio vss 170.133e-18
c3056 n757__i0__i14__net1 vss 46.9324e-18
c3057 n758__i0__i14__net1 vss 27.3568e-18
c3058 n2__i1__net6 vss 96.022e-18
c3059 n1824__chipdriverout vss 237.331e-18
c3060 n1827__chipdriverout vss 182.984e-18
c3061 n1828__chipdriverout vss 207.825e-18
c3062 n1830__chipdriverout vss 184.767e-18
c3063 n1831__chipdriverout vss 211.341e-18
c3064 n1833__chipdriverout vss 195.302e-18
c3065 n1834__chipdriverout vss 211.91e-18
c3066 n1836__chipdriverout vss 231.311e-18
c3067 n1808__chipdriverout vss 143.746e-18
c3068 n1809__chipdriverout vss 218.31e-18
c3069 n1812__chipdriverout vss 171.334e-18
c3070 n1813__chipdriverout vss 207.412e-18
c3071 n1816__chipdriverout vss 247.474e-18
c3072 n753__i0__i14__net1 vss 36.5877e-18
c3073 n754__i0__i14__net1 vss 45.1735e-18
c3074 n9__reset vss 50.7223e-18
c3075 n946__vddio vss 272.89e-18
c3076 n949__vddio vss 239.926e-18
c3077 n950__vddio vss 151.977e-18
c3078 n953__vddio vss 260.862e-18
c3079 n954__vddio vss 157.237e-18
c3080 n957__vddio vss 239.926e-18
c3081 n958__vddio vss 155.935e-18
c3082 n966__vddio vss 164.144e-18
c3083 n1786__chipdriverout vss 16.8472e-18
c3084 n1787__chipdriverout vss 203.991e-18
c3085 n1789__chipdriverout vss 172.793e-18
c3086 n1790__chipdriverout vss 208.876e-18
c3087 n1792__chipdriverout vss 246.912e-18
c3088 n1769__chipdriverout vss 255.831e-18
c3089 n1772__chipdriverout vss 181.508e-18
c3090 n1773__chipdriverout vss 206.756e-18
c3091 n1775__chipdriverout vss 183.425e-18
c3092 n1776__chipdriverout vss 226.138e-18
c3093 n1778__chipdriverout vss 178.064e-18
c3094 n1779__chipdriverout vss 227.164e-18
c3095 n1781__chipdriverout vss 230.743e-18
c3096 n19__i1__net1 vss 152.044e-18
c3097 n34__clk vss 106.735e-18
c3098 n745__i0__i14__net1 vss 35.9632e-18
c3099 n746__i0__i14__net1 vss 44.4247e-18
c3100 n926__vddio vss 262.642e-18
c3101 n929__vddio vss 248.097e-18
c3102 n930__vddio vss 131.64e-18
c3103 n932__vddio vss 235.884e-18
c3104 n933__vddio vss 136.526e-18
c3105 n935__vddio vss 248.097e-18
c3106 n936__vddio vss 135.544e-18
c3107 n938__vddio vss 159.199e-18
c3108 n1729__chipdriverout vss 129.231e-18
c3109 n1732__chipdriverout vss 220.176e-18
c3110 n1733__chipdriverout vss 189.235e-18
c3111 n1736__chipdriverout vss 225.409e-18
c3112 n1737__chipdriverout vss 266.046e-18
c3113 n1740__chipdriverout vss 235.758e-18
c3114 n1741__chipdriverout vss 200.567e-18
c3115 n1744__chipdriverout vss 226.642e-18
c3116 n1745__chipdriverout vss 202.699e-18
c3117 n1748__chipdriverout vss 213.769e-18
c3118 n1749__chipdriverout vss 197.064e-18
c3119 n1752__chipdriverout vss 214.572e-18
c3120 n1753__chipdriverout vss 251.084e-18
c3121 n1409__vddio vss 6.88079e-18
c3122 n33__s vss 40.0569e-18
c3123 n735__i0__i14__net1 vss 43.9937e-18
c3124 n736__i0__i14__net1 vss 37.5452e-18
c3125 n905__vddio vss 283.552e-18
c3126 n908__vddio vss 237.137e-18
c3127 n909__vddio vss 150.61e-18
c3128 n911__vddio vss 257.511e-18
c3129 n912__vddio vss 155.818e-18
c3130 n914__vddio vss 237.137e-18
c3131 n915__vddio vss 154.587e-18
c3132 n917__vddio vss 187.2e-18
c3133 n733__i0__i14__net1 vss 39.3888e-18
c3134 n734__i0__i14__net1 vss 47.7247e-18
c3135 n1708__chipdriverout vss 130.569e-18
c3136 n1709__chipdriverout vss 221.612e-18
c3137 n1711__chipdriverout vss 190.512e-18
c3138 n1712__chipdriverout vss 226.962e-18
c3139 n1714__chipdriverout vss 265.985e-18
c3140 n1691__chipdriverout vss 238.723e-18
c3141 n1694__chipdriverout vss 203.986e-18
c3142 n1695__chipdriverout vss 230.622e-18
c3143 n1697__chipdriverout vss 206.205e-18
c3144 n1698__chipdriverout vss 217.665e-18
c3145 n1700__chipdriverout vss 200.451e-18
c3146 n1701__chipdriverout vss 218.603e-18
c3147 n1703__chipdriverout vss 256.859e-18
c3148 n727__i0__i14__net1 vss 36.6115e-18
c3149 n728__i0__i14__net1 vss 47.7114e-18
c3150 n28__i3__net13 vss 308.765e-18
c3151 n884__vddio vss 276.964e-18
c3152 n887__vddio vss 264.879e-18
c3153 n888__vddio vss 140.588e-18
c3154 n890__vddio vss 253.074e-18
c3155 n891__vddio vss 145.929e-18
c3156 n893__vddio vss 264.879e-18
c3157 n894__vddio vss 144.661e-18
c3158 n896__vddio vss 169.552e-18
c3159 n14__i1__net5 vss 63.1102e-18
c3160 n15__clk4 vss 78.8403e-18
c3161 n725__i0__i14__net1 vss 39.51e-18
c3162 n726__i0__i14__net1 vss 47.8804e-18
c3163 n1669__chipdriverout vss 16.2453e-18
c3164 n1670__chipdriverout vss 205.599e-18
c3165 n1672__chipdriverout vss 174.248e-18
c3166 n1673__chipdriverout vss 210.614e-18
c3167 n1675__chipdriverout vss 246.912e-18
c3168 n1652__chipdriverout vss 258.172e-18
c3169 n1655__chipdriverout vss 184.352e-18
c3170 n1656__chipdriverout vss 210.111e-18
c3171 n1658__chipdriverout vss 186.356e-18
c3172 n1659__chipdriverout vss 229.376e-18
c3173 n1661__chipdriverout vss 180.882e-18
c3174 n1662__chipdriverout vss 230.544e-18
c3175 n1664__chipdriverout vss 233.535e-18
c3176 n721__i0__i14__net1 vss 43.0719e-18
c3177 n722__i0__i14__net1 vss 37.0499e-18
c3178 n9__i3__net11 vss 84.3082e-18
c3179 n6__i1__net5 vss 53.5342e-18
c3180 n862__vddio vss 289.29e-18
c3181 n865__vddio vss 242.648e-18
c3182 n866__vddio vss 153.159e-18
c3183 n869__vddio vss 263.338e-18
c3184 n870__vddio vss 158.573e-18
c3185 n873__vddio vss 242.648e-18
c3186 n874__vddio vss 157.117e-18
c3187 n882__vddio vss 165.463e-18
c3188 n2__r1 vss 67.1989e-18
c3189 n717__i0__i14__net1 vss 47.0251e-18
c3190 n718__i0__i14__net1 vss 38.8677e-18
c3191 n1630__chipdriverout vss 134.386e-18
c3192 n1631__chipdriverout vss 225.566e-18
c3193 n1633__chipdriverout vss 193.893e-18
c3194 n1634__chipdriverout vss 230.918e-18
c3195 n1636__chipdriverout vss 268.761e-18
c3196 n1613__chipdriverout vss 235.828e-18
c3197 n1616__chipdriverout vss 201.068e-18
c3198 n1617__chipdriverout vss 227.776e-18
c3199 n1619__chipdriverout vss 203.39e-18
c3200 n1620__chipdriverout vss 214.707e-18
c3201 n1622__chipdriverout vss 197.598e-18
c3202 n1623__chipdriverout vss 215.881e-18
c3203 n1625__chipdriverout vss 254.371e-18
c3204 n10__clk4 vss 68.5435e-18
c3205 n709__i0__i14__net1 vss 44.7022e-18
c3206 n710__i0__i14__net1 vss 37.0342e-18
c3207 n27__s vss 69.913e-18
c3208 n11__i3__net12 vss 158.859e-18
c3209 n27__i3__net13 vss 155.823e-18
c3210 n842__vddio vss 288.277e-18
c3211 n845__vddio vss 240.065e-18
c3212 n846__vddio vss 150.641e-18
c3213 n848__vddio vss 260.128e-18
c3214 n849__vddio vss 156.254e-18
c3215 n851__vddio vss 240.065e-18
c3216 n852__vddio vss 154.416e-18
c3217 n854__vddio vss 185.542e-18
c3218 n8__i1__net4 vss 61.3233e-18
c3219 n697__i0__i14__net1 vss 47.1191e-18
c3220 n698__i0__i14__net1 vss 38.7501e-18
c3221 n1576__chipdriverout vss 153.493e-18
c3222 n1577__chipdriverout vss 216.391e-18
c3223 n1579__chipdriverout vss 182.592e-18
c3224 n1580__chipdriverout vss 221.561e-18
c3225 n1582__chipdriverout vss 256.646e-18
c3226 n1585__chipdriverout vss 261.836e-18
c3227 n1588__chipdriverout vss 187.111e-18
c3228 n1589__chipdriverout vss 212.339e-18
c3229 n1591__chipdriverout vss 188.872e-18
c3230 n1592__chipdriverout vss 232.107e-18
c3231 n1594__chipdriverout vss 183.555e-18
c3232 n1595__chipdriverout vss 232.769e-18
c3233 n1597__chipdriverout vss 236.299e-18
c3234 n1411__vddio vss 7.41841e-18
c3235 n24__s vss 62.715e-18
c3236 n693__i0__i14__net1 vss 42.8777e-18
c3237 n694__i0__i14__net1 vss 38.7915e-18
c3238 n821__vddio vss 273.746e-18
c3239 n824__vddio vss 241.255e-18
c3240 n825__vddio vss 152.044e-18
c3241 n827__vddio vss 261.722e-18
c3242 n828__vddio vss 157.495e-18
c3243 n830__vddio vss 241.255e-18
c3244 n831__vddio vss 155.942e-18
c3245 n833__vddio vss 187.579e-18
c3246 n681__i0__i14__net1 vss 47.1191e-18
c3247 n682__i0__i14__net1 vss 24.4136e-18
c3248 n2__i1__net4 vss 99.1262e-18
c3249 n1537__chipdriverout vss 16.823e-18
c3250 n1538__chipdriverout vss 216.391e-18
c3251 n1540__chipdriverout vss 182.592e-18
c3252 n1541__chipdriverout vss 221.561e-18
c3253 n1543__chipdriverout vss 256.646e-18
c3254 n1546__chipdriverout vss 257.234e-18
c3255 n1549__chipdriverout vss 183.052e-18
c3256 n1550__chipdriverout vss 208.273e-18
c3257 n1552__chipdriverout vss 184.883e-18
c3258 n1553__chipdriverout vss 227.809e-18
c3259 n1555__chipdriverout vss 179.553e-18
c3260 n1556__chipdriverout vss 228.639e-18
c3261 n1558__chipdriverout vss 232.669e-18
c3262 n25__i3__net13 vss 204.117e-18
c3263 n9__i3__net12 vss 190.557e-18
c3264 n677__i0__i14__net1 vss 35.9802e-18
c3265 n678__i0__i14__net1 vss 47.2533e-18
c3266 n4__reset vss 50.465e-18
c3267 n800__vddio vss 254.863e-18
c3268 n803__vddio vss 255.584e-18
c3269 n804__vddio vss 135.005e-18
c3270 n806__vddio vss 243.752e-18
c3271 n807__vddio vss 140.269e-18
c3272 n809__vddio vss 255.584e-18
c3273 n810__vddio vss 138.854e-18
c3274 n812__vddio vss 162.297e-18
c3275 n12__i1__net1 vss 164.919e-18
c3276 n27__clk vss 102.708e-18
c3277 n6__i3__net11 vss 26.36e-18
c3278 n1485__chipdriverout vss 136.713e-18
c3279 n1486__chipdriverout vss 232.365e-18
c3280 n1488__chipdriverout vss 199.005e-18
c3281 n1489__chipdriverout vss 237.742e-18
c3282 n1491__chipdriverout vss 275.135e-18
c3283 n1494__chipdriverout vss 222.671e-18
c3284 n1497__chipdriverout vss 188.217e-18
c3285 n1498__chipdriverout vss 212.141e-18
c3286 n1500__chipdriverout vss 190.411e-18
c3287 n1501__chipdriverout vss 198.871e-18
c3288 n1503__chipdriverout vss 184.956e-18
c3289 n1504__chipdriverout vss 199.927e-18
c3290 n1506__chipdriverout vss 238.46e-18
c3291 n661__i0__i14__net1 vss 35.9802e-18
c3292 n662__i0__i14__net1 vss 47.4124e-18
c3293 n779__vddio vss 290.53e-18
c3294 n782__vddio vss 242.522e-18
c3295 n783__vddio vss 152.838e-18
c3296 n785__vddio vss 263.118e-18
c3297 n786__vddio vss 158.288e-18
c3298 n788__vddio vss 242.522e-18
c3299 n789__vddio vss 156.767e-18
c3300 n791__vddio vss 165.817e-18
c3301 n6__i3__net12 vss 70.7794e-18
c3302 n22__i3__net13 vss 68.0753e-18
c3303 n1446__chipdriverout vss 152.938e-18
c3304 n1447__chipdriverout vss 215.707e-18
c3305 n1449__chipdriverout vss 182.239e-18
c3306 n1450__chipdriverout vss 220.878e-18
c3307 n1452__chipdriverout vss 255.798e-18
c3308 n1455__chipdriverout vss 249.039e-18
c3309 n1458__chipdriverout vss 176.182e-18
c3310 n1459__chipdriverout vss 199.569e-18
c3311 n1461__chipdriverout vss 178.098e-18
c3312 n1462__chipdriverout vss 218.309e-18
c3313 n1464__chipdriverout vss 172.868e-18
c3314 n1465__chipdriverout vss 219.426e-18
c3315 n1467__chipdriverout vss 226.179e-18
c3316 n641__i0__i14__net1 vss 35.859e-18
c3317 n642__i0__i14__net1 vss 46.4786e-18
c3318 n758__vddio vss 290.364e-18
c3319 n761__vddio vss 243.315e-18
c3320 n762__vddio vss 152.143e-18
c3321 n764__vddio vss 262.515e-18
c3322 n765__vddio vss 157.555e-18
c3323 n767__vddio vss 243.315e-18
c3324 n768__vddio vss 156.137e-18
c3325 n770__vddio vss 191.066e-18
c3326 n10__i3__net9 vss 100.116e-18
c3327 n11__i1__net1 vss 581.848e-18
c3328 n20__i3__net13 vss 113.212e-18
c3329 n637__i0__i14__net1 vss 39.4121e-18
c3330 n638__i0__i14__net1 vss 47.1233e-18
c3331 n1408__chipdriverout vss 230.127e-18
c3332 n1410__chipdriverout vss 197.437e-18
c3333 n1411__chipdriverout vss 235.493e-18
c3334 n1413__chipdriverout vss 272.379e-18
c3335 n1416__chipdriverout vss 236.863e-18
c3336 n1419__chipdriverout vss 201.043e-18
c3337 n1420__chipdriverout vss 226.484e-18
c3338 n1422__chipdriverout vss 203.101e-18
c3339 n1423__chipdriverout vss 214.333e-18
c3340 n1425__chipdriverout vss 197.569e-18
c3341 n1426__chipdriverout vss 215.06e-18
c3342 n1428__chipdriverout vss 250.564e-18
c3343 n629__i0__i14__net1 vss 36.0041e-18
c3344 n630__i0__i14__net1 vss 47.4316e-18
c3345 n16__i3__net13 vss 334.064e-18
c3346 n737__vddio vss 288.127e-18
c3347 n740__vddio vss 241.255e-18
c3348 n741__vddio vss 152.044e-18
c3349 n743__vddio vss 261.722e-18
c3350 n744__vddio vss 157.495e-18
c3351 n746__vddio vss 241.255e-18
c3352 n747__vddio vss 155.942e-18
c3353 n749__vddio vss 187.55e-18
c3354 n14__i1__net3 vss 66.9033e-18
c3355 n11__i3__net10 vss 159.086e-18
c3356 n22__clk vss 132.817e-18
c3357 n1368__chipdriverout vss 136.597e-18
c3358 n1369__chipdriverout vss 232.242e-18
c3359 n1371__chipdriverout vss 182.476e-18
c3360 n1372__chipdriverout vss 237.608e-18
c3361 n1374__chipdriverout vss 256.676e-18
c3362 n1377__chipdriverout vss 257.198e-18
c3363 n1380__chipdriverout vss 182.953e-18
c3364 n1381__chipdriverout vss 224.358e-18
c3365 n1383__chipdriverout vss 184.77e-18
c3366 n1384__chipdriverout vss 227.686e-18
c3367 n1386__chipdriverout vss 179.453e-18
c3368 n1387__chipdriverout vss 228.49e-18
c3369 n1389__chipdriverout vss 232.557e-18
c3370 n6__i1__net3 vss 54.2258e-18
c3371 n613__i0__i14__net1 vss 36.0041e-18
c3372 n614__i0__i14__net1 vss 47.4316e-18
c3373 n716__vddio vss 282.796e-18
c3374 n719__vddio vss 234.895e-18
c3375 n720__vddio vss 147.834e-18
c3376 n722__vddio vss 255.042e-18
c3377 n723__vddio vss 153.322e-18
c3378 n725__vddio vss 234.895e-18
c3379 n726__vddio vss 151.526e-18
c3380 n728__vddio vss 180.632e-18
c3381 n2__r2 vss 98.9437e-18
c3382 n605__i0__i14__net1 vss 38.4335e-18
c3383 n606__i0__i14__net1 vss 42.5841e-18
c3384 n1329__chipdriverout vss 130.303e-18
c3385 n1330__chipdriverout vss 221.431e-18
c3386 n1332__chipdriverout vss 190.262e-18
c3387 n1333__chipdriverout vss 226.408e-18
c3388 n1335__chipdriverout vss 269.901e-18
c3389 n1338__chipdriverout vss 228.805e-18
c3390 n1341__chipdriverout vss 191.809e-18
c3391 n1342__chipdriverout vss 216.098e-18
c3392 n1344__chipdriverout vss 193.841e-18
c3393 n1345__chipdriverout vss 203.216e-18
c3394 n1347__chipdriverout vss 188.44e-18
c3395 n1348__chipdriverout vss 203.864e-18
c3396 n1350__chipdriverout vss 240.684e-18
c3397 n597__i0__i14__net1 vss 38.8931e-18
c3398 n598__i0__i14__net1 vss 34.2068e-18
c3399 n21__clk vss 208.324e-18
c3400 n9__i3__net10 vss 163.191e-18
c3401 n15__s vss 61.1519e-18
c3402 n1__vdd vss 101.389e-18
c3403 n695__vddio vss 255.78e-18
c3404 n698__vddio vss 255.307e-18
c3405 n699__vddio vss 135.129e-18
c3406 n701__vddio vss 243.604e-18
c3407 n702__vddio vss 140.322e-18
c3408 n704__vddio vss 255.307e-18
c3409 n705__vddio vss 139.041e-18
c3410 n707__vddio vss 186.573e-18
c3411 n2__vdd vss 55.0632e-18
c3412 n585__i0__i14__net1 vss 43.8592e-18
c3413 n586__i0__i14__net1 vss 37.2432e-18
c3414 n1288__chipdriverout vss 16.7666e-18
c3415 n1289__chipdriverout vss 205.938e-18
c3416 n1292__chipdriverout vss 174.407e-18
c3417 n1293__chipdriverout vss 211.095e-18
c3418 n1296__chipdriverout vss 247.474e-18
c3419 n1297__chipdriverout vss 260.218e-18
c3420 n1300__chipdriverout vss 186.402e-18
c3421 n1301__chipdriverout vss 212.717e-18
c3422 n1304__chipdriverout vss 188.539e-18
c3423 n1305__chipdriverout vss 232.036e-18
c3424 n1308__chipdriverout vss 182.931e-18
c3425 n1309__chipdriverout vss 233.424e-18
c3426 n1312__chipdriverout vss 238.215e-18
c3427 n6__i3__net9 vss 25.8576e-18
c3428 n12__s vss 61.26e-18
c3429 n581__i0__i14__net1 vss 39.4273e-18
c3430 n582__i0__i14__net1 vss 34.3664e-18
c3431 n674__vddio vss 264.368e-18
c3432 n677__vddio vss 266.298e-18
c3433 n678__vddio vss 141.264e-18
c3434 n680__vddio vss 254.439e-18
c3435 n681__vddio vss 146.691e-18
c3436 n683__vddio vss 266.298e-18
c3437 n684__vddio vss 145.337e-18
c3438 n686__vddio vss 170.251e-18
c3439 n569__i0__i14__net1 vss 44.0826e-18
c3440 n570__i0__i14__net1 vss 38.9107e-18
c3441 n6__i3__net10 vss 67.7941e-18
c3442 n6__i1__net1 vss 43.3808e-18
c3443 n1251__chipdriverout vss 130.441e-18
c3444 n1252__chipdriverout vss 221.195e-18
c3445 n1254__chipdriverout vss 190.097e-18
c3446 n1255__chipdriverout vss 226.559e-18
c3447 n1257__chipdriverout vss 263.235e-18
c3448 n1260__chipdriverout vss 240.603e-18
c3449 n1263__chipdriverout vss 205.671e-18
c3450 n1264__chipdriverout vss 232.35e-18
c3451 n1266__chipdriverout vss 207.916e-18
c3452 n1267__chipdriverout vss 219.269e-18
c3453 n1269__chipdriverout vss 202.135e-18
c3454 n1270__chipdriverout vss 220.226e-18
c3455 n1272__chipdriverout vss 258.404e-18
c3456 n16__clk vss 88.649e-18
c3457 n18__clk vss 74.2137e-18
c3458 n652__vddio vss 287.296e-18
c3459 n655__vddio vss 241.559e-18
c3460 n656__vddio vss 152.678e-18
c3461 n659__vddio vss 261.681e-18
c3462 n660__vddio vss 158.138e-18
c3463 n663__vddio vss 241.559e-18
c3464 n664__vddio vss 156.655e-18
c3465 n672__vddio vss 195.405e-18
c3466 n1212__chipdriverout vss 129.493e-18
c3467 n1213__chipdriverout vss 220.69e-18
c3468 n1215__chipdriverout vss 189.75e-18
c3469 n1216__chipdriverout vss 225.938e-18
c3470 n1218__chipdriverout vss 264.694e-18
c3471 n1221__chipdriverout vss 234.915e-18
c3472 n1224__chipdriverout vss 199.579e-18
c3473 n1225__chipdriverout vss 225.112e-18
c3474 n1227__chipdriverout vss 201.732e-18
c3475 n1228__chipdriverout vss 212.067e-18
c3476 n1230__chipdriverout vss 196.076e-18
c3477 n1231__chipdriverout vss 212.881e-18
c3478 n1233__chipdriverout vss 256.598e-18
c3479 n549__i0__i14__net1 vss 45.9509e-18
c3480 n550__i0__i14__net1 vss 39.1525e-18
c3481 n632__vddio vss 283.162e-18
c3482 n635__vddio vss 235.075e-18
c3483 n636__vddio vss 149.161e-18
c3484 n638__vddio vss 255.221e-18
c3485 n639__vddio vss 154.5e-18
c3486 n641__vddio vss 235.075e-18
c3487 n642__vddio vss 153.05e-18
c3488 n644__vddio vss 160.81e-18
c3489 n1174__chipdriverout vss 217.37e-18
c3490 n1176__chipdriverout vss 186.769e-18
c3491 n1177__chipdriverout vss 222.346e-18
c3492 n1179__chipdriverout vss 264.787e-18
c3493 n1182__chipdriverout vss 236.498e-18
c3494 n1185__chipdriverout vss 199.136e-18
c3495 n1186__chipdriverout vss 223.482e-18
c3496 n1188__chipdriverout vss 201.073e-18
c3497 n1189__chipdriverout vss 210.594e-18
c3498 n1191__chipdriverout vss 195.691e-18
c3499 n1192__chipdriverout vss 211.015e-18
c3500 n1194__chipdriverout vss 246.718e-18
c3501 n533__i0__i14__net1 vss 45.6239e-18
c3502 n534__i0__i14__net1 vss 28.0681e-18
c3503 n610__vddio vss 275.807e-18
c3504 n613__vddio vss 239.027e-18
c3505 n614__vddio vss 151.006e-18
c3506 n617__vddio vss 259.721e-18
c3507 n618__vddio vss 156.401e-18
c3508 n621__vddio vss 239.027e-18
c3509 n622__vddio vss 154.902e-18
c3510 n630__vddio vss 162.891e-18
c3511 n525__i0__i14__net1 vss 36.4965e-18
c3512 n526__i0__i14__net1 vss 45.8393e-18
c3513 n1131__chipdriverout vss 129.231e-18
c3514 n1134__chipdriverout vss 220.208e-18
c3515 n1135__chipdriverout vss 189.267e-18
c3516 n1138__chipdriverout vss 225.441e-18
c3517 n1139__chipdriverout vss 266.095e-18
c3518 n1142__chipdriverout vss 236.474e-18
c3519 n1143__chipdriverout vss 200.565e-18
c3520 n1146__chipdriverout vss 226.4e-18
c3521 n1147__chipdriverout vss 202.693e-18
c3522 n1150__chipdriverout vss 213.361e-18
c3523 n1151__chipdriverout vss 197.094e-18
c3524 n1154__chipdriverout vss 214.148e-18
c3525 n1155__chipdriverout vss 248.836e-18
c3526 n517__i0__i14__net1 vss 46.5771e-18
c3527 n518__i0__i14__net1 vss 27.9483e-18
c3528 n590__vddio vss 281.232e-18
c3529 n593__vddio vss 245.184e-18
c3530 n594__vddio vss 154.576e-18
c3531 n596__vddio vss 265.908e-18
c3532 n597__vddio vss 159.993e-18
c3533 n599__vddio vss 245.184e-18
c3534 n600__vddio vss 158.595e-18
c3535 n602__vddio vss 167.392e-18
c3536 n509__i0__i14__net1 vss 36.4965e-18
c3537 n510__i0__i14__net1 vss 47.2711e-18
c3538 n1092__chipdriverout vss 132.302e-18
c3539 n1095__chipdriverout vss 223.495e-18
c3540 n1096__chipdriverout vss 192.214e-18
c3541 n1099__chipdriverout vss 228.999e-18
c3542 n1100__chipdriverout vss 265.971e-18
c3543 n1103__chipdriverout vss 239.228e-18
c3544 n1104__chipdriverout vss 205.207e-18
c3545 n1107__chipdriverout vss 232.482e-18
c3546 n1108__chipdriverout vss 207.577e-18
c3547 n1111__chipdriverout vss 219.38e-18
c3548 n1112__chipdriverout vss 201.671e-18
c3549 n1115__chipdriverout vss 220.596e-18
c3550 n1116__chipdriverout vss 259.262e-18
c3551 n501__i0__i14__net1 vss 46.5259e-18
c3552 n502__i0__i14__net1 vss 26.278e-18
c3553 n568__vddio vss 276.231e-18
c3554 n571__vddio vss 244.074e-18
c3555 n572__vddio vss 153.826e-18
c3556 n575__vddio vss 264.026e-18
c3557 n576__vddio vss 159.426e-18
c3558 n579__vddio vss 244.074e-18
c3559 n580__vddio vss 157.803e-18
c3560 n588__vddio vss 195.872e-18
c3561 n1057__chipdriverout vss 220.659e-18
c3562 n1059__chipdriverout vss 189.719e-18
c3563 n1060__chipdriverout vss 225.908e-18
c3564 n1062__chipdriverout vss 264.663e-18
c3565 n1065__chipdriverout vss 234.894e-18
c3566 n1068__chipdriverout vss 199.549e-18
c3567 n1069__chipdriverout vss 225.082e-18
c3568 n1071__chipdriverout vss 201.701e-18
c3569 n1072__chipdriverout vss 212.067e-18
c3570 n1074__chipdriverout vss 196.046e-18
c3571 n1075__chipdriverout vss 212.881e-18
c3572 n1077__chipdriverout vss 256.05e-18
c3573 n548__vddio vss 270.619e-18
c3574 n551__vddio vss 237.986e-18
c3575 n552__vddio vss 151.065e-18
c3576 n554__vddio vss 258.344e-18
c3577 n555__vddio vss 156.382e-18
c3578 n557__vddio vss 237.986e-18
c3579 n558__vddio vss 155.043e-18
c3580 n560__vddio vss 186.481e-18
c3581 n473__i0__i14__net1 vss 37.7771e-18
c3582 n474__i0__i14__net1 vss 47.0195e-18
c3583 n1017__chipdriverout vss 130.458e-18
c3584 n1018__chipdriverout vss 229.227e-18
c3585 n1020__chipdriverout vss 196.68e-18
c3586 n1021__chipdriverout vss 234.36e-18
c3587 n1023__chipdriverout vss 277.332e-18
c3588 n1026__chipdriverout vss 231.464e-18
c3589 n1029__chipdriverout vss 194.704e-18
c3590 n1030__chipdriverout vss 218.701e-18
c3591 n1032__chipdriverout vss 196.545e-18
c3592 n1033__chipdriverout vss 205.875e-18
c3593 n1035__chipdriverout vss 191.265e-18
c3594 n1036__chipdriverout vss 206.163e-18
c3595 n1038__chipdriverout vss 242.198e-18
c3596 n469__i0__i14__net1 vss 45.4774e-18
c3597 n470__i0__i14__net1 vss 26.5591e-18
c3598 n526__vddio vss 275.331e-18
c3599 n529__vddio vss 238.829e-18
c3600 n530__vddio vss 151.523e-18
c3601 n533__vddio vss 259.85e-18
c3602 n534__vddio vss 156.7e-18
c3603 n537__vddio vss 238.829e-18
c3604 n538__vddio vss 155.516e-18
c3605 n546__vddio vss 188.376e-18
c3606 n978__chipdriverout vss 134.797e-18
c3607 n979__chipdriverout vss 234.075e-18
c3608 n981__chipdriverout vss 200.291e-18
c3609 n982__chipdriverout vss 239.64e-18
c3610 n984__chipdriverout vss 274.166e-18
c3611 n987__chipdriverout vss 229.121e-18
c3612 n990__chipdriverout vss 192.918e-18
c3613 n991__chipdriverout vss 217.394e-18
c3614 n993__chipdriverout vss 195.139e-18
c3615 n994__chipdriverout vss 204.135e-18
c3616 n996__chipdriverout vss 189.59e-18
c3617 n997__chipdriverout vss 205.232e-18
c3618 n999__chipdriverout vss 250.338e-18
c3619 n453__i0__i14__net1 vss 46.5918e-18
c3620 n454__i0__i14__net1 vss 26.3619e-18
c3621 n506__vddio vss 280.84e-18
c3622 n509__vddio vss 245.57e-18
c3623 n510__vddio vss 154.167e-18
c3624 n512__vddio vss 265.948e-18
c3625 n513__vddio vss 159.818e-18
c3626 n515__vddio vss 245.57e-18
c3627 n516__vddio vss 158.079e-18
c3628 n518__vddio vss 167.171e-18
c3629 n441__i0__i14__net1 vss 36.0524e-18
c3630 n442__i0__i14__net1 vss 49.1825e-18
c3631 n940__chipdriverout vss 227.402e-18
c3632 n942__chipdriverout vss 194.893e-18
c3633 n943__chipdriverout vss 232.687e-18
c3634 n945__chipdriverout vss 274.76e-18
c3635 n948__chipdriverout vss 224.123e-18
c3636 n951__chipdriverout vss 189.056e-18
c3637 n952__chipdriverout vss 212.36e-18
c3638 n954__chipdriverout vss 191.05e-18
c3639 n955__chipdriverout vss 199.194e-18
c3640 n957__chipdriverout vss 185.794e-18
c3641 n958__chipdriverout vss 199.915e-18
c3642 n960__chipdriverout vss 238.593e-18
c3643 n1420__vddio vss 26.1201e-18
c3644 n437__i0__i14__net1 vss 46.3992e-18
c3645 n438__i0__i14__net1 vss 25.1881e-18
c3646 n485__vddio vss 276.114e-18
c3647 n488__vddio vss 239.254e-18
c3648 n489__vddio vss 150.753e-18
c3649 n491__vddio vss 259.674e-18
c3650 n492__vddio vss 156.215e-18
c3651 n494__vddio vss 239.254e-18
c3652 n495__vddio vss 154.586e-18
c3653 n497__vddio vss 185.748e-18
c3654 n425__i0__i14__net1 vss 35.4449e-18
c3655 n426__i0__i14__net1 vss 48.8857e-18
c3656 n897__chipdriverout vss 137.932e-18
c3657 n900__chipdriverout vss 237.804e-18
c3658 n901__chipdriverout vss 201.686e-18
c3659 n904__chipdriverout vss 241.447e-18
c3660 n905__chipdriverout vss 274.135e-18
c3661 n908__chipdriverout vss 235.913e-18
c3662 n909__chipdriverout vss 199.76e-18
c3663 n912__chipdriverout vss 224.772e-18
c3664 n913__chipdriverout vss 201.642e-18
c3665 n916__chipdriverout vss 212.029e-18
c3666 n917__chipdriverout vss 196.259e-18
c3667 n920__chipdriverout vss 212.375e-18
c3668 n921__chipdriverout vss 246.602e-18
c3669 n464__vddio vss 275.415e-18
c3670 n467__vddio vss 256.022e-18
c3671 n468__vddio vss 151.425e-18
c3672 n470__vddio vss 260.368e-18
c3673 n471__vddio vss 156.764e-18
c3674 n473__vddio vss 239.8e-18
c3675 n474__vddio vss 155.34e-18
c3676 n476__vddio vss 163.522e-18
c3677 n413__i0__i14__net1 vss 36.1015e-18
c3678 n414__i0__i14__net1 vss 48.6098e-18
c3679 n884__chipdriverout vss 128.895e-18
c3680 n885__chipdriverout vss 210.594e-18
c3681 n887__chipdriverout vss 195.068e-18
c3682 n888__chipdriverout vss 233.364e-18
c3683 n890__chipdriverout vss 274.72e-18
c3684 n859__chipdriverout vss 242.42e-18
c3685 n860__chipdriverout vss 189.991e-18
c3686 n863__chipdriverout vss 216.679e-18
c3687 n864__chipdriverout vss 192.089e-18
c3688 n867__chipdriverout vss 219.959e-18
c3689 n868__chipdriverout vss 202.259e-18
c3690 n871__chipdriverout vss 221.045e-18
c3691 n872__chipdriverout vss 242.867e-18
c3692 n443__vddio vss 282.785e-18
c3693 n446__vddio vss 250.577e-18
c3694 n447__vddio vss 157.012e-18
c3695 n449__vddio vss 270.934e-18
c3696 n450__vddio vss 162.794e-18
c3697 n452__vddio vss 250.577e-18
c3698 n453__vddio vss 161.004e-18
c3699 n455__vddio vss 170.669e-18
c3700 n397__i0__i14__net1 vss 36.1436e-18
c3701 n398__i0__i14__net1 vss 49.4289e-18
c3702 n823__chipdriverout vss 230.092e-18
c3703 n825__chipdriverout vss 196.711e-18
c3704 n826__chipdriverout vss 235.482e-18
c3705 n828__chipdriverout vss 274.751e-18
c3706 n831__chipdriverout vss 227.964e-18
c3707 n834__chipdriverout vss 193.092e-18
c3708 n835__chipdriverout vss 217.007e-18
c3709 n837__chipdriverout vss 195.159e-18
c3710 n838__chipdriverout vss 203.906e-18
c3711 n840__chipdriverout vss 189.764e-18
c3712 n841__chipdriverout vss 204.712e-18
c3713 n843__chipdriverout vss 247.194e-18
c3714 n422__vddio vss 274.611e-18
c3715 n425__vddio vss 243.522e-18
c3716 n426__vddio vss 153.206e-18
c3717 n428__vddio vss 264.011e-18
c3718 n429__vddio vss 158.746e-18
c3719 n431__vddio vss 243.522e-18
c3720 n432__vddio vss 157.118e-18
c3721 n434__vddio vss 166.179e-18
c3722 n381__i0__i14__net1 vss 23.4515e-18
c3723 n382__i0__i14__net1 vss 49.6232e-18
c3724 n783__chipdriverout vss 130.399e-18
c3725 n784__chipdriverout vss 223.732e-18
c3726 n786__chipdriverout vss 191.128e-18
c3727 n787__chipdriverout vss 229.124e-18
c3728 n789__chipdriverout vss 266.547e-18
c3729 n792__chipdriverout vss 227.937e-18
c3730 n795__chipdriverout vss 193.054e-18
c3731 n796__chipdriverout vss 216.94e-18
c3732 n798__chipdriverout vss 195.105e-18
c3733 n799__chipdriverout vss 203.796e-18
c3734 n801__chipdriverout vss 189.726e-18
c3735 n802__chipdriverout vss 204.575e-18
c3736 n804__chipdriverout vss 243.624e-18
c3737 n1422__vddio vss 7.40101e-18
c3738 n401__vddio vss 290.286e-18
c3739 n404__vddio vss 243.284e-18
c3740 n405__vddio vss 153.158e-18
c3741 n407__vddio vss 263.851e-18
c3742 n408__vddio vss 158.681e-18
c3743 n410__vddio vss 243.284e-18
c3744 n411__vddio vss 157.07e-18
c3745 n413__vddio vss 189.72e-18
c3746 n365__i0__i14__net1 vss 36.8008e-18
c3747 n366__i0__i14__net1 vss 49.6071e-18
c3748 n759__chipdriverout vss 128.71e-18
c3749 n760__chipdriverout vss 222.694e-18
c3750 n762__chipdriverout vss 190.704e-18
c3751 n763__chipdriverout vss 227.829e-18
c3752 n765__chipdriverout vss 267.345e-18
c3753 n742__chipdriverout vss 227.22e-18
c3754 n745__chipdriverout vss 190.767e-18
c3755 n746__chipdriverout vss 213.691e-18
c3756 n748__chipdriverout vss 192.535e-18
c3757 n749__chipdriverout vss 200.815e-18
c3758 n751__chipdriverout vss 187.439e-18
c3759 n752__chipdriverout vss 201.074e-18
c3760 n754__chipdriverout vss 238.819e-18
c3761 n380__vddio vss 285.25e-18
c3762 n383__vddio vss 238.315e-18
c3763 n384__vddio vss 151.424e-18
c3764 n386__vddio vss 259.41e-18
c3765 n387__vddio vss 156.536e-18
c3766 n389__vddio vss 238.315e-18
c3767 n390__vddio vss 155.415e-18
c3768 n392__vddio vss 187.436e-18
c3769 n349__i0__i14__net1 vss 39.2586e-18
c3770 n350__i0__i14__net1 vss 47.5344e-18
c3771 n705__chipdriverout vss 235.585e-18
c3772 n706__chipdriverout vss 201.548e-18
c3773 n709__chipdriverout vss 241.089e-18
c3774 n710__chipdriverout vss 279.557e-18
c3775 n713__chipdriverout vss 230.308e-18
c3776 n714__chipdriverout vss 196.094e-18
c3777 n717__chipdriverout vss 220.884e-18
c3778 n718__chipdriverout vss 198.294e-18
c3779 n721__chipdriverout vss 207.682e-18
c3780 n722__chipdriverout vss 192.694e-18
c3781 n725__chipdriverout vss 208.683e-18
c3782 n726__chipdriverout vss 247.298e-18
c3783 n359__vddio vss 270.866e-18
c3784 n362__vddio vss 258.633e-18
c3785 n363__vddio vss 137.428e-18
c3786 n365__vddio vss 246.532e-18
c3787 n366__vddio vss 142.59e-18
c3788 n368__vddio vss 258.633e-18
c3789 n369__vddio vss 141.473e-18
c3790 n371__vddio vss 190.866e-18
c3791 n333__i0__i14__net1 vss 39.3888e-18
c3792 n334__i0__i14__net1 vss 47.7247e-18
c3793 n663__chipdriverout vss 127.572e-18
c3794 n666__chipdriverout vss 216.806e-18
c3795 n667__chipdriverout vss 186.398e-18
c3796 n670__chipdriverout vss 222.052e-18
c3797 n671__chipdriverout vss 261.579e-18
c3798 n674__chipdriverout vss 235.789e-18
c3799 n675__chipdriverout vss 200.615e-18
c3800 n678__chipdriverout vss 226.735e-18
c3801 n679__chipdriverout vss 202.763e-18
c3802 n682__chipdriverout vss 213.904e-18
c3803 n683__chipdriverout vss 197.112e-18
c3804 n686__chipdriverout vss 214.736e-18
c3805 n687__chipdriverout vss 252.058e-18
c3806 n338__vddio vss 267.9e-18
c3807 n341__vddio vss 253.719e-18
c3808 n342__vddio vss 134.806e-18
c3809 n344__vddio vss 241.567e-18
c3810 n345__vddio vss 139.826e-18
c3811 n347__vddio vss 253.719e-18
c3812 n348__vddio vss 138.799e-18
c3813 n350__vddio vss 190.659e-18
c3814 n317__i0__i14__net1 vss 39.3388e-18
c3815 n318__i0__i14__net1 vss 47.529e-18
c3816 n627__chipdriverout vss 231.48e-18
c3817 n628__chipdriverout vss 198.134e-18
c3818 n631__chipdriverout vss 236.858e-18
c3819 n632__chipdriverout vss 274.139e-18
c3820 n635__chipdriverout vss 232.591e-18
c3821 n636__chipdriverout vss 197.977e-18
c3822 n639__chipdriverout vss 224.089e-18
c3823 n640__chipdriverout vss 200.208e-18
c3824 n643__chipdriverout vss 211.084e-18
c3825 n644__chipdriverout vss 194.541e-18
c3826 n647__chipdriverout vss 212.115e-18
c3827 n648__chipdriverout vss 251.741e-18
c3828 n317__vddio vss 256.928e-18
c3829 n320__vddio vss 256.79e-18
c3830 n321__vddio vss 135.763e-18
c3831 n323__vddio vss 244.877e-18
c3832 n324__vddio vss 141.028e-18
c3833 n326__vddio vss 256.79e-18
c3834 n327__vddio vss 139.655e-18
c3835 n329__vddio vss 163.222e-18
c3836 n301__i0__i14__net1 vss 39.3559e-18
c3837 n302__i0__i14__net1 vss 48.9492e-18
c3838 n588__chipdriverout vss 231.48e-18
c3839 n589__chipdriverout vss 198.134e-18
c3840 n592__chipdriverout vss 236.858e-18
c3841 n593__chipdriverout vss 274.139e-18
c3842 n596__chipdriverout vss 228.76e-18
c3843 n597__chipdriverout vss 191.818e-18
c3844 n600__chipdriverout vss 215.836e-18
c3845 n601__chipdriverout vss 193.914e-18
c3846 n604__chipdriverout vss 202.754e-18
c3847 n605__chipdriverout vss 188.491e-18
c3848 n608__chipdriverout vss 203.621e-18
c3849 n609__chipdriverout vss 242.483e-18
c3850 n296__vddio vss 259.06e-18
c3851 n299__vddio vss 258.852e-18
c3852 n300__vddio vss 137.031e-18
c3853 n302__vddio vss 247.099e-18
c3854 n303__vddio vss 142.283e-18
c3855 n305__vddio vss 258.852e-18
c3856 n306__vddio vss 140.975e-18
c3857 n308__vddio vss 165.846e-18
c3858 n281__i0__i14__net1 vss 39.3559e-18
c3859 n282__i0__i14__net1 vss 48.9492e-18
c3860 n546__chipdriverout vss 132.669e-18
c3861 n549__chipdriverout vss 231.48e-18
c3862 n550__chipdriverout vss 198.134e-18
c3863 n553__chipdriverout vss 236.858e-18
c3864 n554__chipdriverout vss 274.139e-18
c3865 n557__chipdriverout vss 232.033e-18
c3866 n558__chipdriverout vss 194.452e-18
c3867 n561__chipdriverout vss 218.572e-18
c3868 n562__chipdriverout vss 196.457e-18
c3869 n565__chipdriverout vss 205.649e-18
c3870 n566__chipdriverout vss 191.052e-18
c3871 n569__chipdriverout vss 206.301e-18
c3872 n570__chipdriverout vss 245.244e-18
c3873 n275__vddio vss 267.861e-18
c3874 n278__vddio vss 255.84e-18
c3875 n279__vddio vss 136.104e-18
c3876 n281__vddio vss 243.863e-18
c3877 n282__vddio vss 141.11e-18
c3878 n284__vddio vss 255.84e-18
c3879 n285__vddio vss 140.149e-18
c3880 n287__vddio vss 165.708e-18
c3881 n265__i0__i14__net1 vss 39.3559e-18
c3882 n266__i0__i14__net1 vss 47.5465e-18
c3883 n510__chipdriverout vss 231.357e-18
c3884 n511__chipdriverout vss 198.017e-18
c3885 n514__chipdriverout vss 236.723e-18
c3886 n515__chipdriverout vss 274.139e-18
c3887 n518__chipdriverout vss 235.744e-18
c3888 n519__chipdriverout vss 200.557e-18
c3889 n522__chipdriverout vss 226.64e-18
c3890 n523__chipdriverout vss 202.692e-18
c3891 n526__chipdriverout vss 213.794e-18
c3892 n527__chipdriverout vss 197.054e-18
c3893 n530__chipdriverout vss 214.602e-18
c3894 n531__chipdriverout vss 252.084e-18
c3895 n261__i0__i14__net1 vss 30.896e-18
c3896 n262__i0__i14__net1 vss 37.5816e-18
c3897 n254__vddio vss 265.436e-18
c3898 n257__vddio vss 253.534e-18
c3899 n258__vddio vss 134.707e-18
c3900 n260__vddio vss 241.366e-18
c3901 n261__vddio vss 139.712e-18
c3902 n263__vddio vss 253.534e-18
c3903 n264__vddio vss 138.7e-18
c3904 n266__vddio vss 190.209e-18
c3905 n249__i0__i14__net1 vss 39.3559e-18
c3906 n250__i0__i14__net1 vss 47.5465e-18
c3907 n468__chipdriverout vss 132.94e-18
c3908 n471__chipdriverout vss 233.043e-18
c3909 n472__chipdriverout vss 199.614e-18
c3910 n475__chipdriverout vss 238.292e-18
c3911 n476__chipdriverout vss 278.335e-18
c3912 n479__chipdriverout vss 235.364e-18
c3913 n480__chipdriverout vss 199.686e-18
c3914 n483__chipdriverout vss 225.297e-18
c3915 n484__chipdriverout vss 201.714e-18
c3916 n487__chipdriverout vss 212.545e-18
c3917 n488__chipdriverout vss 196.183e-18
c3918 n491__chipdriverout vss 213.157e-18
c3919 n492__chipdriverout vss 252.44e-18
c3920 n1426__vddio vss 7.33789e-18
c3921 n245__i0__i14__net1 vss 30.6968e-18
c3922 n246__i0__i14__net1 vss 37.6209e-18
c3923 n233__vddio vss 279.987e-18
c3924 n236__vddio vss 233.994e-18
c3925 n237__vddio vss 149.029e-18
c3926 n239__vddio vss 254.443e-18
c3927 n240__vddio vss 154.113e-18
c3928 n242__vddio vss 233.994e-18
c3929 n243__vddio vss 152.978e-18
c3930 n245__vddio vss 183.891e-18
c3931 n233__i0__i14__net1 vss 38.7575e-18
c3932 n234__i0__i14__net1 vss 46.1609e-18
c3933 n432__chipdriverout vss 132.399e-18
c3934 n433__chipdriverout vss 223.402e-18
c3935 n435__chipdriverout vss 192.085e-18
c3936 n436__chipdriverout vss 228.939e-18
c3937 n438__chipdriverout vss 263.268e-18
c3938 n441__chipdriverout vss 231.586e-18
c3939 n444__chipdriverout vss 198.275e-18
c3940 n445__chipdriverout vss 223.58e-18
c3941 n447__chipdriverout vss 200.63e-18
c3942 n448__chipdriverout vss 210.182e-18
c3943 n450__chipdriverout vss 194.876e-18
c3944 n451__chipdriverout vss 211.466e-18
c3945 n453__chipdriverout vss 252.608e-18
c3946 n229__i0__i14__net1 vss 30.6486e-18
c3947 n230__i0__i14__net1 vss 40.3899e-18
c3948 n212__vddio vss 294.441e-18
c3949 n215__vddio vss 248.249e-18
c3950 n216__vddio vss 155.36e-18
c3951 n218__vddio vss 268.414e-18
c3952 n219__vddio vss 161.162e-18
c3953 n221__vddio vss 248.249e-18
c3954 n222__vddio vss 159.271e-18
c3955 n224__vddio vss 191.828e-18
c3956 n217__i0__i14__net1 vss 39.4862e-18
c3957 n218__i0__i14__net1 vss 46.6008e-18
c3958 n394__chipdriverout vss 221.472e-18
c3959 n396__chipdriverout vss 190.56e-18
c3960 n397__chipdriverout vss 226.694e-18
c3961 n399__chipdriverout vss 265.321e-18
c3962 n402__chipdriverout vss 226.034e-18
c3963 n405__chipdriverout vss 191.011e-18
c3964 n406__chipdriverout vss 214.926e-18
c3965 n408__chipdriverout vss 193.077e-18
c3966 n409__chipdriverout vss 201.975e-18
c3967 n411__chipdriverout vss 187.683e-18
c3968 n412__chipdriverout vss 202.781e-18
c3969 n414__chipdriverout vss 240.927e-18
c3970 n213__i0__i14__net1 vss 29.4975e-18
c3971 n214__i0__i14__net1 vss 38.9707e-18
c3972 n191__vddio vss 285.691e-18
c3973 n194__vddio vss 238.932e-18
c3974 n195__vddio vss 150.543e-18
c3975 n197__vddio vss 259.28e-18
c3976 n198__vddio vss 155.988e-18
c3977 n200__vddio vss 238.932e-18
c3978 n201__vddio vss 154.377e-18
c3979 n203__vddio vss 162.061e-18
c3980 n201__i0__i14__net1 vss 39.4862e-18
c3981 n202__i0__i14__net1 vss 45.1691e-18
c3982 n354__chipdriverout vss 129.946e-18
c3983 n355__chipdriverout vss 221.533e-18
c3984 n357__chipdriverout vss 190.621e-18
c3985 n358__chipdriverout vss 226.755e-18
c3986 n360__chipdriverout vss 265.381e-18
c3987 n363__chipdriverout vss 233.258e-18
c3988 n366__chipdriverout vss 197.92e-18
c3989 n367__chipdriverout vss 223.708e-18
c3990 n369__chipdriverout vss 200.084e-18
c3991 n370__chipdriverout vss 210.736e-18
c3992 n372__chipdriverout vss 194.483e-18
c3993 n373__chipdriverout vss 211.613e-18
c3994 n375__chipdriverout vss 248.695e-18
c3995 n170__vddio vss 285.855e-18
c3996 n173__vddio vss 236.428e-18
c3997 n174__vddio vss 149.81e-18
c3998 n176__vddio vss 256.662e-18
c3999 n177__vddio vss 155.078e-18
c4000 n179__vddio vss 236.428e-18
c4001 n180__vddio vss 153.725e-18
c4002 n182__vddio vss 161.822e-18
c4003 n185__i0__i14__net1 vss 39.4452e-18
c4004 n186__i0__i14__net1 vss 46.5905e-18
c4005 n315__chipdriverout vss 129.946e-18
c4006 n316__chipdriverout vss 221.533e-18
c4007 n318__chipdriverout vss 190.621e-18
c4008 n319__chipdriverout vss 226.755e-18
c4009 n321__chipdriverout vss 265.381e-18
c4010 n324__chipdriverout vss 236.849e-18
c4011 n327__chipdriverout vss 201.079e-18
c4012 n328__chipdriverout vss 226.875e-18
c4013 n330__chipdriverout vss 203.159e-18
c4014 n331__chipdriverout vss 213.989e-18
c4015 n333__chipdriverout vss 197.576e-18
c4016 n334__chipdriverout vss 214.667e-18
c4017 n336__chipdriverout vss 256.91e-18
c4018 n1428__vddio vss 7.65006e-18
c4019 n181__i0__i14__net1 vss 31.2888e-18
c4020 n182__i0__i14__net1 vss 26.3173e-18
c4021 n149__vddio vss 273.237e-18
c4022 n152__vddio vss 239.108e-18
c4023 n153__vddio vss 151.583e-18
c4024 n155__vddio vss 259.613e-18
c4025 n156__vddio vss 156.831e-18
c4026 n158__vddio vss 239.108e-18
c4027 n159__vddio vss 155.575e-18
c4028 n161__vddio vss 188.407e-18
c4029 n169__i0__i14__net1 vss 39.395e-18
c4030 n170__i0__i14__net1 vss 47.9716e-18
c4031 n277__chipdriverout vss 221.533e-18
c4032 n279__chipdriverout vss 190.621e-18
c4033 n280__chipdriverout vss 226.755e-18
c4034 n282__chipdriverout vss 265.381e-18
c4035 n285__chipdriverout vss 229.74e-18
c4036 n288__chipdriverout vss 194.196e-18
c4037 n289__chipdriverout vss 218.213e-18
c4038 n291__chipdriverout vss 196.173e-18
c4039 n292__chipdriverout vss 205.303e-18
c4040 n294__chipdriverout vss 190.797e-18
c4041 n295__chipdriverout vss 205.894e-18
c4042 n297__chipdriverout vss 245.169e-18
c4043 n165__i0__i14__net1 vss 31.2888e-18
c4044 n166__i0__i14__net1 vss 38.5719e-18
c4045 n128__vddio vss 288.003e-18
c4046 n131__vddio vss 241.553e-18
c4047 n132__vddio vss 152.286e-18
c4048 n134__vddio vss 262.156e-18
c4049 n135__vddio vss 157.712e-18
c4050 n137__vddio vss 241.553e-18
c4051 n138__vddio vss 156.198e-18
c4052 n140__vddio vss 188.555e-18
c4053 n153__i0__i14__net1 vss 39.395e-18
c4054 n154__i0__i14__net1 vss 46.3544e-18
c4055 n237__chipdriverout vss 129.946e-18
c4056 n238__chipdriverout vss 221.533e-18
c4057 n240__chipdriverout vss 190.621e-18
c4058 n241__chipdriverout vss 226.755e-18
c4059 n243__chipdriverout vss 265.381e-18
c4060 n246__chipdriverout vss 226.034e-18
c4061 n249__chipdriverout vss 191.073e-18
c4062 n250__chipdriverout vss 214.987e-18
c4063 n252__chipdriverout vss 193.139e-18
c4064 n253__chipdriverout vss 201.975e-18
c4065 n255__chipdriverout vss 187.745e-18
c4066 n256__chipdriverout vss 202.781e-18
c4067 n258__chipdriverout vss 241.609e-18
c4068 n149__i0__i14__net1 vss 31.2888e-18
c4069 n150__i0__i14__net1 vss 38.5719e-18
c4070 n107__vddio vss 285.227e-18
c4071 n110__vddio vss 238.716e-18
c4072 n111__vddio vss 150.443e-18
c4073 n113__vddio vss 259.079e-18
c4074 n114__vddio vss 155.874e-18
c4075 n116__vddio vss 238.716e-18
c4076 n117__vddio vss 154.278e-18
c4077 n119__vddio vss 161.955e-18
c4078 n137__i0__i14__net1 vss 37.8595e-18
c4079 n138__i0__i14__net1 vss 44.9227e-18
c4080 n198__chipdriverout vss 136.286e-18
c4081 n199__chipdriverout vss 234.821e-18
c4082 n201__chipdriverout vss 201.194e-18
c4083 n202__chipdriverout vss 240.239e-18
c4084 n204__chipdriverout vss 278.072e-18
c4085 n207__chipdriverout vss 227.456e-18
c4086 n210__chipdriverout vss 193.165e-18
c4087 n211__chipdriverout vss 218.938e-18
c4088 n213__chipdriverout vss 195.478e-18
c4089 n214__chipdriverout vss 205.598e-18
c4090 n216__chipdriverout vss 189.848e-18
c4091 n217__chipdriverout vss 206.834e-18
c4092 n219__chipdriverout vss 244.129e-18
c4093 n133__i0__i14__net1 vss 32.4671e-18
c4094 n134__i0__i14__net1 vss 26.4116e-18
c4095 n86__vddio vss 274.676e-18
c4096 n89__vddio vss 238.2e-18
c4097 n90__vddio vss 150.844e-18
c4098 n92__vddio vss 259.035e-18
c4099 n93__vddio vss 156.074e-18
c4100 n95__vddio vss 238.2e-18
c4101 n96__vddio vss 154.759e-18
c4102 n98__vddio vss 186.23e-18
c4103 n121__i0__i14__net1 vss 36.4727e-18
c4104 n122__i0__i14__net1 vss 48.4611e-18
c4105 n160__chipdriverout vss 231.094e-18
c4106 n162__chipdriverout vss 197.684e-18
c4107 n163__chipdriverout vss 236.497e-18
c4108 n165__chipdriverout vss 275.778e-18
c4109 n168__chipdriverout vss 241.353e-18
c4110 n171__chipdriverout vss 203.298e-18
c4111 n172__chipdriverout vss 229.101e-18
c4112 n174__chipdriverout vss 205.296e-18
c4113 n175__chipdriverout vss 216.445e-18
c4114 n177__chipdriverout vss 199.742e-18
c4115 n178__chipdriverout vss 216.972e-18
c4116 n180__chipdriverout vss 254.411e-18
c4117 n117__i0__i14__net1 vss 33.4203e-18
c4118 n118__i0__i14__net1 vss 27.5461e-18
c4119 n65__vddio vss 285.274e-18
c4120 n68__vddio vss 250.577e-18
c4121 n69__vddio vss 157.073e-18
c4122 n71__vddio vss 270.995e-18
c4123 n72__vddio vss 162.855e-18
c4124 n74__vddio vss 250.577e-18
c4125 n75__vddio vss 161.065e-18
c4126 n77__vddio vss 193.978e-18
c4127 n105__i0__i14__net1 vss 36.6857e-18
c4128 n106__i0__i14__net1 vss 49.1825e-18
c4129 n135__chipdriverout vss 136.391e-18
c4130 n136__chipdriverout vss 231.631e-18
c4131 n138__chipdriverout vss 198.221e-18
c4132 n139__chipdriverout vss 237.049e-18
c4133 n141__chipdriverout vss 274.431e-18
c4134 n118__chipdriverout vss 227.964e-18
c4135 n121__chipdriverout vss 193.092e-18
c4136 n122__chipdriverout vss 217.007e-18
c4137 n124__chipdriverout vss 195.159e-18
c4138 n125__chipdriverout vss 203.906e-18
c4139 n127__chipdriverout vss 189.764e-18
c4140 n128__chipdriverout vss 204.712e-18
c4141 n130__chipdriverout vss 243.628e-18
c4142 n101__i0__i14__net1 vss 32.4566e-18
c4143 n102__i0__i14__net1 vss 25.1777e-18
c4144 n44__vddio vss 280.846e-18
c4145 n47__vddio vss 243.522e-18
c4146 n48__vddio vss 153.206e-18
c4147 n50__vddio vss 264.011e-18
c4148 n51__vddio vss 158.746e-18
c4149 n53__vddio vss 243.522e-18
c4150 n54__vddio vss 157.118e-18
c4151 n56__vddio vss 189.329e-18
c4152 n89__i0__i14__net1 vss 36.6353e-18
c4153 n90__i0__i14__net1 vss 48.9774e-18
c4154 n96__chipdriverout vss 136.391e-18
c4155 n97__chipdriverout vss 231.692e-18
c4156 n99__chipdriverout vss 198.282e-18
c4157 n100__chipdriverout vss 237.111e-18
c4158 n102__chipdriverout vss 274.477e-18
c4159 n79__chipdriverout vss 227.952e-18
c4160 n82__chipdriverout vss 193.153e-18
c4161 n83__chipdriverout vss 217.067e-18
c4162 n85__chipdriverout vss 195.219e-18
c4163 n86__chipdriverout vss 203.906e-18
c4164 n88__chipdriverout vss 189.825e-18
c4165 n89__chipdriverout vss 204.712e-18
c4166 n91__chipdriverout vss 243.834e-18
c4167 n85__i0__i14__net1 vss 34.3867e-18
c4168 n86__i0__i14__net1 vss 26.8472e-18
c4169 n23__vddio vss 280.627e-18
c4170 n26__vddio vss 243.393e-18
c4171 n27__vddio vss 153.206e-18
c4172 n29__vddio vss 263.918e-18
c4173 n30__vddio vss 158.62e-18
c4174 n32__vddio vss 243.412e-18
c4175 n33__vddio vss 157.008e-18
c4176 n35__vddio vss 166.179e-18
c4177 n73__i0__i14__net1 vss 36.6408e-18
c4178 n74__i0__i14__net1 vss 48.9832e-18
c4179 n58__chipdriverout vss 232.258e-18
c4180 n60__chipdriverout vss 198.79e-18
c4181 n61__chipdriverout vss 237.712e-18
c4182 n63__chipdriverout vss 274.626e-18
c4183 n40__chipdriverout vss 228.192e-18
c4184 n43__chipdriverout vss 193.627e-18
c4185 n44__chipdriverout vss 217.658e-18
c4186 n46__chipdriverout vss 195.703e-18
c4187 n47__chipdriverout vss 204.456e-18
c4188 n49__chipdriverout vss 190.267e-18
c4189 n50__chipdriverout vss 205.331e-18
c4190 n52__chipdriverout vss 243.612e-18
c4191 n2__vddio vss 276.437e-18
c4192 n5__vddio vss 243.002e-18
c4193 n6__vddio vss 157.589e-18
c4194 n8__vddio vss 268.276e-18
c4195 n9__vddio vss 163.072e-18
c4196 n11__vddio vss 242.923e-18
c4197 n12__vddio vss 161.459e-18
c4198 n14__vddio vss 243.596e-18
c4199 n62__i0__i14__net1 vss 59.0966e-18
c4200 n61__i0__i14__net1 vss 33.6952e-18
c4201 n18__chipdriverout vss 91.5715e-18
c4202 n19__chipdriverout vss 154.485e-18
c4203 n21__chipdriverout vss 131.229e-18
c4204 n22__chipdriverout vss 158.014e-18
c4205 n24__chipdriverout vss 186.869e-18
c4206 n14__chipdriverout vss 167.4e-18
c4207 n12__chipdriverout vss 137.259e-18
c4208 n11__chipdriverout vss 154.457e-18
c4209 n9__chipdriverout vss 137.956e-18
c4210 n8__chipdriverout vss 149.136e-18
c4211 n6__chipdriverout vss 134.623e-18
c4212 n5__chipdriverout vss 150.09e-18
c4213 n2__chipdriverout vss 178.594e-18
c4214 n1394__vddio vss 24.6158e-15
c4215 n1737__vddio vss 49.4214e-18
c4216 n23__i0__net4 vss 98.7531e-18
c4217 n1756__vddio vss 45.9718e-18
c4218 n1757__vddio vss 49.6238e-18
c4219 n9__i0__i11__outinv vss 130.27e-18
c4220 n1758__vddio vss 59.724e-18
c4221 n19__i0__net4 vss 95.253e-18
c4222 n22__i0__net4 vss 72.2803e-18
c4223 n5__i0__i11__outinv vss 88.1617e-18
c4224 n8__i0__i11__outinv vss 82.7012e-18
c4225 n50__i0__net3 vss 698.354e-21
c4226 n1759__vddio vss 148.85e-18
c4227 n1760__vddio vss 153.678e-18
c4228 n1761__vddio vss 149.159e-18
c4229 n1762__vddio vss 246.831e-18
c4230 n1763__vddio vss 247.103e-18
c4231 n62__i0__net3 vss 21.2074e-21
c4232 n1764__vddio vss 191.308e-18
c4233 n1638__vddio vss 130.477e-18
c4234 n214__i0__i13__net1 vss 346.443e-18
c4235 n1630__vddio vss 231.777e-18
c4236 n203__i0__i13__net1 vss 341.305e-18
c4237 n1623__vddio vss 230.246e-18
c4238 n192__i0__i13__net1 vss 349.006e-18
c4239 n1617__vddio vss 134.225e-18
c4240 n1609__vddio vss 109.509e-18
c4241 n327__i0__net2 vss 310.535e-18
c4242 n1602__vddio vss 227.965e-18
c4243 n318__i0__net2 vss 306.294e-18
c4244 n1595__vddio vss 226.52e-18
c4245 n305__i0__net2 vss 312.264e-18
c4246 n1588__vddio vss 230.146e-18
c4247 n296__i0__net2 vss 317.331e-18
c4248 n1581__vddio vss 231.588e-18
c4249 n287__i0__net2 vss 311.36e-18
c4250 n1574__vddio vss 227.965e-18
c4251 n278__i0__net2 vss 306.294e-18
c4252 n1568__vddio vss 232.456e-18
c4253 n269__i0__net2 vss 317.331e-18
c4254 n1560__vddio vss 231.588e-18
c4255 n260__i0__net2 vss 311.36e-18
c4256 n1553__vddio vss 227.965e-18
c4257 n251__i0__net2 vss 317.568e-18
c4258 n1546__vddio vss 233.113e-18
c4259 n246__i0__net2 vss 306.174e-18
c4260 n1539__vddio vss 225.449e-18
c4261 n233__i0__net2 vss 217.105e-18
c4262 n208__i0__i13__net1 vss 237.17e-18
c4263 n197__i0__i13__net1 vss 241.956e-18
c4264 n186__i0__i13__net1 vss 236.111e-18
c4265 n321__i0__net2 vss 216.182e-18
c4266 n312__i0__net2 vss 223.318e-18
c4267 n308__i0__net2 vss 220.473e-18
c4268 n299__i0__net2 vss 246.483e-18
c4269 n290__i0__net2 vss 236.09e-18
c4270 n281__i0__net2 vss 238.474e-18
c4271 n272__i0__net2 vss 239.516e-18
c4272 n263__i0__net2 vss 236.011e-18
c4273 n254__i0__net2 vss 237.622e-18
c4274 n240__i0__net2 vss 246.575e-18
c4275 n236__i0__net2 vss 152.579e-18
c4276 n1375__vddio vss 237.365e-18
c4277 n1298__i0__i14__net1 vss 400.634e-18
c4278 n1354__vddio vss 423.418e-18
c4279 n1259__i0__i14__net1 vss 397.53e-18
c4280 n1333__vddio vss 412.23e-18
c4281 n1209__i0__i14__net1 vss 375.185e-18
c4282 n1312__vddio vss 408.093e-18
c4283 n1170__i0__i14__net1 vss 373.936e-18
c4284 n1291__vddio vss 418.36e-18
c4285 n1142__i0__i14__net1 vss 395.809e-18
c4286 n1270__vddio vss 422.307e-18
c4287 n1103__i0__i14__net1 vss 397.53e-18
c4288 n1249__vddio vss 412.23e-18
c4289 n1053__i0__i14__net1 vss 375.185e-18
c4290 n1241__vddio vss 408.093e-18
c4291 n1014__i0__i14__net1 vss 388.352e-18
c4292 n1207__vddio vss 413.35e-18
c4293 n986__i0__i14__net1 vss 397.53e-18
c4294 n1186__vddio vss 422.212e-18
c4295 n947__i0__i14__net1 vss 395.81e-18
c4296 n1165__vddio vss 418.264e-18
c4297 n908__i0__i14__net1 vss 392.536e-18
c4298 n11__vdd vss 55.5706e-18
c4299 n1144__vddio vss 409.153e-18
c4300 n869__i0__i14__net1 vss 393.952e-18
c4301 n5__vdd vss 86.2085e-18
c4302 n6__pinout vss 84.9533e-18
c4303 n1123__vddio vss 413.291e-18
c4304 n12__vdd vss 85.134e-18
c4305 n1286__i0__i14__net1 vss 289.667e-18
c4306 n1247__i0__i14__net1 vss 286.725e-18
c4307 n1223__i0__i14__net1 vss 416.043e-18
c4308 n1184__i0__i14__net1 vss 286.805e-18
c4309 n1130__i0__i14__net1 vss 286.697e-18
c4310 n1091__i0__i14__net1 vss 416.081e-18
c4311 n1067__i0__i14__net1 vss 286.695e-18
c4312 n1028__i0__i14__net1 vss 298.469e-18
c4313 n974__i0__i14__net1 vss 412.373e-18
c4314 n935__i0__i14__net1 vss 275.719e-18
c4315 n896__i0__i14__net1 vss 275.662e-18
c4316 n6__vdd vss 1.86021e-15
c4317 n5__pinout vss 55.6886e-18
c4318 n857__i0__i14__net1 vss 412.487e-18
c4319 n4__pinout vss 49.5099e-18
c4320 n830__i0__i14__net1 vss 397.53e-18
c4321 n1102__vddio vss 423.666e-18
c4322 n791__i0__i14__net1 vss 400.446e-18
c4323 n16__pinin vss 72.7122e-18
c4324 n1081__vddio vss 229.739e-18
c4325 n2__i1__i3__net24 vss 49.5176e-18
c4326 n13__vdd vss 64.2927e-18
c4327 n5__i1__i3__net22 vss 46.9182e-18
c4328 n2__i1__i3__net21 vss 50.3085e-18
c4329 n15__vdd vss 63.3429e-18
c4330 n818__i0__i14__net1 vss 275.454e-18
c4331 n14__pinin vss 98.247e-18
c4332 n779__i0__i14__net1 vss 277.139e-18
c4333 n18__pinin vss 55.6852e-18
c4334 n2__i1__i3__net25 vss 36.1948e-18
c4335 n7__i1__i3__net22 vss 33.7394e-18
c4336 n2__i1__i3__net23 vss 34.9864e-18
c4337 n5__i1__net7 vss 33.2632e-18
c4338 n3__r0 vss 56.0637e-18
c4339 n1901__chipdriverout vss 421.942e-18
c4340 n11__i1__net7 vss 67.5487e-18
c4341 n10__i1__net6 vss 46.9926e-18
c4342 n1862__chipdriverout vss 294.689e-18
c4343 n5__i1__i11__net4 vss 160.87e-18
c4344 n7__i1__net7 vss 141.583e-18
c4345 n1011__vddio vss 226.706e-18
c4346 n1__r0 vss 64.2223e-18
c4347 n1887__chipdriverout vss 376.816e-18
c4348 n9__i1__net7 vss 183.695e-18
c4349 n8__i1__net6 vss 55.5936e-18
c4350 n990__vddio vss 409.538e-18
c4351 n1848__chipdriverout vss 388.962e-18
c4352 n7__i1__i11__net4 vss 103.578e-18
c4353 n18__vdd vss 76.8258e-18
c4354 n982__vddio vss 435.925e-18
c4355 n1818__chipdriverout vss 281.969e-18
c4356 n5__i1__net6 vss 58.9837e-18
c4357 n1784__chipdriverout vss 410.372e-18
c4358 n2__i1__i2__net25 vss 35.0258e-18
c4359 n1763__chipdriverout vss 286.351e-18
c4360 n36__s vss 26.8005e-18
c4361 n40__vdd vss 617.226e-18
c4362 n7__i1__i2__net22 vss 33.8468e-18
c4363 n1706__chipdriverout vss 289.992e-18
c4364 n2__i1__i2__net23 vss 37.8086e-18
c4365 n6__i3__i6__net1 vss 53.8467e-18
c4366 n1825__chipdriverout vss 365.589e-18
c4367 n961__vddio vss 416.748e-18
c4368 n3__i1__net6 vss 75.9299e-18
c4369 n1770__chipdriverout vss 370.111e-18
c4370 n927__vddio vss 398.572e-18
c4371 n2__i1__i2__net24 vss 51.3199e-18
c4372 n21__vdd vss 65.8011e-18
c4373 n1756__chipdriverout vss 374.482e-18
c4374 n35__s vss 40.5393e-18
c4375 n64__vdd vss 64.6398e-18
c4376 n5__i1__i2__net22 vss 46.754e-18
c4377 n906__vddio vss 407.751e-18
c4378 n1692__chipdriverout vss 381.459e-18
c4379 n4__i3__i6__net1 vss 71.1957e-18
c4380 n2__i1__i2__net21 vss 50.2537e-18
c4381 n885__vddio vss 430.87e-18
c4382 n23__vdd vss 62.0044e-18
c4383 n62__vdd vss 87.7046e-18
c4384 n1653__chipdriverout vss 376.521e-18
c4385 n8__i3__net11 vss 58.5868e-18
c4386 n7__i1__net5 vss 144.512e-18
c4387 n59__vdd vss 56.6038e-18
c4388 n877__vddio vss 421.235e-18
c4389 n4__r1 vss 64.7379e-18
c4390 n1667__chipdriverout vss 415.657e-18
c4391 n10__i3__net11 vss 225.512e-21
c4392 n5__i1__net5 vss 35.5701e-18
c4393 n5__r1 vss 56.9705e-18
c4394 n1614__chipdriverout vss 382.167e-18
c4395 n9__i1__net5 vss 187.219e-18
c4396 n8__clk4 vss 30.2366e-18
c4397 n9__i1__net4 vss 55.8688e-18
c4398 n843__vddio vss 418.275e-18
c4399 n7__i1__i10__net4 vss 104.069e-18
c4400 n2__i3__i1__net3 vss 49.3969e-18
c4401 n1586__chipdriverout vss 370.638e-18
c4402 n26__vdd vss 77.2075e-18
c4403 n57__vdd vss 67.061e-18
c4404 n1628__chipdriverout vss 293.317e-18
c4405 n11__i1__net5 vss 68.5133e-18
c4406 n11__clk4 vss 25.4834e-18
c4407 n10__i1__net4 vss 46.5826e-18
c4408 n5__i1__i10__net4 vss 156.037e-18
c4409 n2__i3__i1__net5 vss 34.7522e-18
c4410 n1574__chipdriverout vss 275.715e-18
c4411 n7__i3__i1__net2 vss 32.6366e-18
c4412 n1535__chipdriverout vss 412.483e-18
c4413 n2__i3__i1__net1 vss 34.111e-18
c4414 n5__i1__net4 vss 59.2768e-18
c4415 n1483__chipdriverout vss 275.716e-18
c4416 n822__vddio vss 419.994e-18
c4417 n5__i3__i1__net2 vss 45.2795e-18
c4418 n1547__chipdriverout vss 369.576e-18
c4419 n801__vddio vss 417.169e-18
c4420 n2__i3__i1__net4 vss 49.1103e-18
c4421 n3__i1__net4 vss 75.9804e-18
c4422 n54__vdd vss 63.2494e-18
c4423 n1495__chipdriverout vss 394.216e-18
c4424 n2__i1__i1__net25 vss 35.615e-18
c4425 n7__i3__net12 vss 28.5485e-18
c4426 n1444__chipdriverout vss 274.578e-18
c4427 n780__vddio vss 422.21e-18
c4428 n2__i1__i1__net24 vss 51.3517e-18
c4429 n5__i3__net12 vss 43.546e-18
c4430 n29__vdd vss 66.0728e-18
c4431 n51__vdd vss 57.8601e-18
c4432 n1456__chipdriverout vss 394.729e-18
c4433 n5__i1__i1__net22 vss 45.6305e-18
c4434 n9__i3__net9 vss 62.0719e-18
c4435 n759__vddio vss 422.483e-18
c4436 n48__vdd vss 57.6616e-18
c4437 n7__i1__i1__net22 vss 34.1207e-18
c4438 n1417__chipdriverout vss 368.079e-18
c4439 n2__i1__i1__net21 vss 49.2645e-18
c4440 n18__i3__net13 vss 30.3202e-18
c4441 n31__vdd vss 61.3561e-18
c4442 n738__vddio vss 419.994e-18
c4443 n1405__chipdriverout vss 409.892e-18
c4444 n2__i1__i1__net23 vss 38.6484e-18
c4445 n14__i3__net13 vss 58.28e-21
c4446 n1366__chipdriverout vss 275.445e-18
c4447 n2__i3__i0__net5 vss 35.1426e-18
c4448 n5__i1__net3 vss 35.731e-18
c4449 n3__r2 vss 57.0189e-18
c4450 n1327__chipdriverout vss 280.254e-18
c4451 n7__i3__i0__net2 vss 32.1311e-18
c4452 n11__i1__net3 vss 68.8262e-18
c4453 n4__vdd vss 47.0091e-18
c4454 n2__i3__i0__net1 vss 31.817e-18
c4455 n5__i1__i9__net4 vss 163.929e-18
c4456 n1314__chipdriverout vss 420.979e-18
c4457 n1378__chipdriverout vss 368.939e-18
c4458 n2__i3__i0__net3 vss 49.304e-18
c4459 n7__i1__net3 vss 140.197e-18
c4460 n46__vdd vss 67.0723e-18
c4461 n1__r2 vss 63.4215e-18
c4462 n717__vddio vss 409.93e-18
c4463 n1339__chipdriverout vss 375.787e-18
c4464 n5__i3__i0__net2 vss 45.2795e-18
c4465 n9__i1__net3 vss 182.91e-18
c4466 n3__vdd vss 53.3465e-18
c4467 n696__vddio vss 416.211e-18
c4468 n2__i3__i0__net4 vss 48.8309e-18
c4469 n7__i1__i9__net4 vss 100.773e-18
c4470 n1320__chipdriverout vss 382.898e-18
c4471 n43__vdd vss 63.8148e-18
c4472 n34__vdd vss 74.2435e-18
c4473 n7__i3__net10 vss 28.0255e-18
c4474 n7__i1__net1 vss 28.5988e-18
c4475 n1249__chipdriverout vss 289.317e-18
c4476 n675__vddio vss 433.247e-18
c4477 n5__i3__net10 vss 43.7894e-18
c4478 n5__i1__net1 vss 46.4775e-18
c4479 n1261__chipdriverout vss 382.072e-18
c4480 n39__vdd vss 46.0699e-18
c4481 n37__vdd vss 50.9817e-18
c4482 n667__vddio vss 415.036e-18
c4483 n1222__chipdriverout vss 393.222e-18
c4484 n633__vddio vss 403.754e-18
c4485 n1183__chipdriverout vss 377.408e-18
c4486 n625__vddio vss 416.112e-18
c4487 n1164__chipdriverout vss 371.969e-18
c4488 n591__vddio vss 426.488e-18
c4489 n1125__chipdriverout vss 388.967e-18
c4490 n583__vddio vss 419.198e-18
c4491 n1066__chipdriverout vss 393.222e-18
c4492 n549__vddio vss 408.777e-18
c4493 n1027__chipdriverout vss 371.842e-18
c4494 n541__vddio vss 415.516e-18
c4495 n988__chipdriverout vss 402.595e-18
c4496 n507__vddio vss 426.535e-18
c4497 n949__chipdriverout vss 384.401e-18
c4498 n486__vddio vss 416.729e-18
c4499 n930__chipdriverout vss 361.974e-18
c4500 n465__vddio vss 418.044e-18
c4501 n875__chipdriverout vss 387.465e-18
c4502 n444__vddio vss 434.606e-18
c4503 n832__chipdriverout vss 394.198e-18
c4504 n423__vddio vss 423.225e-18
c4505 n793__chipdriverout vss 393.511e-18
c4506 n402__vddio vss 422.849e-18
c4507 n743__chipdriverout vss 378.439e-18
c4508 n381__vddio vss 413.787e-18
c4509 n729__chipdriverout vss 407.857e-18
c4510 n360__vddio vss 416.915e-18
c4511 n690__chipdriverout vss 375.185e-18
c4512 n339__vddio vss 408.093e-18
c4513 n651__chipdriverout vss 373.936e-18
c4514 n318__vddio vss 418.357e-18
c4515 n612__chipdriverout vss 395.809e-18
c4516 n297__vddio vss 422.305e-18
c4517 n573__chipdriverout vss 397.53e-18
c4518 n276__vddio vss 412.23e-18
c4519 n534__chipdriverout vss 374.614e-18
c4520 n255__vddio vss 407.751e-18
c4521 n495__chipdriverout vss 369.244e-18
c4522 n234__vddio vss 402.226e-18
c4523 n442__chipdriverout vss 416.017e-18
c4524 n213__vddio vss 431.054e-18
c4525 n403__chipdriverout vss 394.198e-18
c4526 n192__vddio vss 415.317e-18
c4527 n364__chipdriverout vss 369.979e-18
c4528 n171__vddio vss 408.039e-18
c4529 n325__chipdriverout vss 371.228e-18
c4530 n150__vddio vss 412.9e-18
c4531 n286__chipdriverout vss 395.919e-18
c4532 n129__vddio vss 419.989e-18
c4533 n247__chipdriverout vss 394.198e-18
c4534 n108__vddio vss 414.976e-18
c4535 n208__chipdriverout vss 367.73e-18
c4536 n87__vddio vss 414.753e-18
c4537 n169__chipdriverout vss 372.237e-18
c4538 n66__vddio vss 434.508e-18
c4539 n119__chipdriverout vss 394.198e-18
c4540 n45__vddio vss 423.127e-18
c4541 n80__chipdriverout vss 394.198e-18
c4542 n24__vddio vss 423.036e-18
c4543 n41__chipdriverout vss 396.559e-18
c4544 n3__vddio vss 422.247e-18
c4545 n1210__chipdriverout vss 286.803e-18
c4546 n1171__chipdriverout vss 403.992e-18
c4547 n1158__chipdriverout vss 286.344e-18
c4548 n1119__chipdriverout vss 294.693e-18
c4549 n1054__chipdriverout vss 416.214e-18
c4550 n1015__chipdriverout vss 270.642e-18
c4551 n976__chipdriverout vss 282.216e-18
c4552 n937__chipdriverout vss 402.57e-18
c4553 n924__chipdriverout vss 287.157e-18
c4554 n882__chipdriverout vss 270.646e-18
c4555 n820__chipdriverout vss 408.851e-18
c4556 n781__chipdriverout vss 272.563e-18
c4557 n757__chipdriverout vss 261.753e-18
c4558 n736__chipdriverout vss 416.807e-18
c4559 n697__chipdriverout vss 284.628e-18
c4560 n658__chipdriverout vss 408.604e-18
c4561 n619__chipdriverout vss 408.224e-18
c4562 n580__chipdriverout vss 275.439e-18
c4563 n541__chipdriverout vss 407.749e-18
c4564 n502__chipdriverout vss 274.725e-18
c4565 n430__chipdriverout vss 296.238e-18
c4566 n391__chipdriverout vss 415.543e-18
c4567 n352__chipdriverout vss 285.631e-18
c4568 n313__chipdriverout vss 286.54e-18
c4569 n274__chipdriverout vss 415.655e-18
c4570 n235__chipdriverout vss 285.597e-18
c4571 n196__chipdriverout vss 277.914e-18
c4572 n157__chipdriverout vss 412.919e-18
c4573 n133__chipdriverout vss 276.243e-18
c4574 n94__chipdriverout vss 276.276e-18
c4575 n55__chipdriverout vss 414.255e-18
c4576 n3__chipdriverout vss 275.493e-18
c4577 n16__chipdriverout vss 195.337e-18
c4578 n17__chipdriverout vss 63.0825e-18
c4579 n56__chipdriverout vss 86.078e-18
c4580 n95__chipdriverout vss 85.8048e-18
c4581 n134__chipdriverout vss 85.6783e-18
c4582 n158__chipdriverout vss 85.6567e-18
c4583 n197__chipdriverout vss 85.7944e-18
c4584 n236__chipdriverout vss 84.2061e-18
c4585 n275__chipdriverout vss 84.6516e-18
c4586 n314__chipdriverout vss 84.1956e-18
c4587 n353__chipdriverout vss 84.311e-18
c4588 n392__chipdriverout vss 84.2061e-18
c4589 n431__chipdriverout vss 89.5233e-18
c4590 n503__chipdriverout vss 85.5479e-18
c4591 n542__chipdriverout vss 85.7949e-18
c4592 n581__chipdriverout vss 85.5721e-18
c4593 n620__chipdriverout vss 86.0722e-18
c4594 n659__chipdriverout vss 84.8873e-18
c4595 n698__chipdriverout vss 85.6027e-18
c4596 n737__chipdriverout vss 85.5558e-18
c4597 n758__chipdriverout vss 77.5159e-18
c4598 n782__chipdriverout vss 87.3926e-18
c4599 n821__chipdriverout vss 86.3413e-18
c4600 n883__chipdriverout vss 87.5316e-18
c4601 n925__chipdriverout vss 87.0089e-18
c4602 n938__chipdriverout vss 87.4503e-18
c4603 n977__chipdriverout vss 86.9894e-18
c4604 n2__i3__net9 vss 15.8329e-18
c4605 n1016__chipdriverout vss 90.6405e-18
c4606 n1055__chipdriverout vss 84.5521e-18
c4607 n2__i3__i0__net2 vss 18.2893e-18
c4608 n1120__chipdriverout vss 84.6535e-18
c4609 n2__i1__net3 vss 12.2402e-18
c4610 n1159__chipdriverout vss 84.5385e-18
c4611 n1172__chipdriverout vss 85.039e-18
c4612 n2__i1__i1__net22 vss 18.1402e-18
c4613 n1211__chipdriverout vss 84.5179e-18
c4614 n2__i3__net11 vss 15.697e-18
c4615 n1250__chipdriverout vss 84.6683e-18
c4616 n2__i3__i1__net2 vss 18.7346e-18
c4617 n1315__chipdriverout vss 84.5416e-18
c4618 n1328__chipdriverout vss 84.9255e-18
c4619 n6__i3__i0__net2 vss 37.1712e-18
c4620 n1367__chipdriverout vss 85.4121e-18
c4621 n5__clk4 vss 22.277e-18
c4622 n2__i1__net5 vss 12.2402e-18
c4623 n1406__chipdriverout vss 84.5905e-18
c4624 n17__i3__net13 vss 43.111e-18
c4625 n1445__chipdriverout vss 85.7583e-18
c4626 n6__i1__i1__net22 vss 35.8485e-18
c4627 n2__i1__i2__net22 vss 17.8722e-18
c4628 n1484__chipdriverout vss 85.2848e-18
c4629 n1536__chipdriverout vss 85.5028e-18
c4630 n6__i3__i1__net2 vss 36.8775e-18
c4631 n1575__chipdriverout vss 85.2533e-18
c4632 n1629__chipdriverout vss 89.0933e-18
c4633 n9__clk4 vss 36.1027e-18
c4634 n1668__chipdriverout vss 84.5521e-18
c4635 n13__clk4 vss 15.483e-18
c4636 n2__i1__net7 vss 11.895e-18
c4637 n1707__chipdriverout vss 84.6788e-18
c4638 n5__i3__i6__net1 vss 55.4778e-18
c4639 n1764__chipdriverout vss 84.5473e-18
c4640 n6__i1__i2__net22 vss 36.6966e-18
c4641 n2__i1__i3__net22 vss 17.2019e-18
c4642 n1785__chipdriverout vss 85.0286e-18
c4643 n1819__chipdriverout vss 84.5464e-18
c4644 n1863__chipdriverout vss 84.664e-18
c4645 n41__s vss 441.627e-18
c4646 n2__pinin vss 31.6009e-18
c4647 n3__pinin vss 19.1063e-18
c4648 n4__pinin vss 17.7903e-18
c4649 n5__pinin vss 17.3866e-18
c4650 n1902__chipdriverout vss 85.3596e-18
c4651 n40__clk vss 177.714e-18
c4652 n6__i1__i3__net22 vss 35.6668e-18
c4653 n780__i0__i14__net1 vss 85.9045e-18
c4654 n819__i0__i14__net1 vss 84.5905e-18
c4655 n858__i0__i14__net1 vss 85.7688e-18
c4656 n3__pinout vss 65.1293e-18
c4657 n8__vdd vss 13.1588e-18
c4658 n14__vdd vss 65.3664e-18
c4659 n17__vdd vss 27.6157e-18
c4660 n22__vdd vss 116.063e-18
c4661 n25__vdd vss 51.6536e-18
c4662 n30__vdd vss 109.785e-18
c4663 n33__vdd vss 41.4433e-18
c4664 n36__vdd vss 180.13e-18
c4665 n38__vdd vss 114.691e-18
c4666 n42__vdd vss 35.0596e-18
c4667 n45__vdd vss 45.1255e-18
c4668 n47__vdd vss 29.1281e-18
c4669 n50__vdd vss 5.74826e-18
c4670 n53__vdd vss 32.4474e-18
c4671 n56__vdd vss 44.9225e-18
c4672 n58__vdd vss 29.3273e-18
c4673 n61__vdd vss 6.88334e-18
c4674 n897__i0__i14__net1 vss 85.277e-18
c4675 n936__i0__i14__net1 vss 85.4924e-18
c4676 n975__i0__i14__net1 vss 85.2533e-18
c4677 n1029__i0__i14__net1 vss 89.1038e-18
c4678 n1068__i0__i14__net1 vss 84.5416e-18
c4679 n1092__i0__i14__net1 vss 84.6683e-18
c4680 n1131__i0__i14__net1 vss 84.5473e-18
c4681 n1185__i0__i14__net1 vss 85.039e-18
c4682 n1224__i0__i14__net1 vss 84.5385e-18
c4683 n1248__i0__i14__net1 vss 84.6535e-18
c4684 n1287__i0__i14__net1 vss 85.3596e-18
c4685 n1434__vddio vss 2.39407e-18
c4686 n1435__vddio vss 2.60774e-18
c4687 n1441__vddio vss 2.95034e-18
c4688 n1442__vddio vss 2.95992e-18
c4689 n1445__vddio vss 3.09055e-18
c4690 n1446__vddio vss 2.96903e-18
c4691 n1449__vddio vss 2.65883e-18
c4692 n1450__vddio vss 1.5955e-18
c4693 n1453__vddio vss 1.31702e-18
c4694 n1454__vddio vss 1.48453e-18
c4695 n1457__vddio vss 2.80809e-18
c4696 n1458__vddio vss 1.29251e-18
c4697 n1461__vddio vss 2.87205e-18
c4698 n1462__vddio vss 1.44714e-18
c4699 n1465__vddio vss 2.76763e-18
c4700 n1466__vddio vss 944.92e-21
c4701 n1467__vddio vss 7.85163e-18
c4702 n1469__vddio vss 2.93403e-18
c4703 n1470__vddio vss 1.58715e-18
c4704 n1471__vddio vss 6.78894e-18
c4705 n1473__vddio vss 2.61642e-18
c4706 n1474__vddio vss 1.50225e-18
c4707 n1475__vddio vss 6.9345e-18
c4708 n1477__vddio vss 2.62011e-18
c4709 n1478__vddio vss 1.61419e-18
c4710 n1479__vddio vss 6.42533e-18
c4711 n1481__vddio vss 2.68193e-18
c4712 n1482__vddio vss 1.60244e-18
c4713 n1485__vddio vss 2.74375e-18
c4714 n1486__vddio vss 1.49972e-18
c4715 n1487__vddio vss 7.0864e-18
c4716 n1489__vddio vss 2.69195e-18
c4717 n1490__vddio vss 1.44791e-18
c4718 n1493__vddio vss 2.87152e-18
c4719 n1494__vddio vss 1.2799e-18
c4720 n1497__vddio vss 2.98544e-18
c4721 n1498__vddio vss 1.3946e-18
c4722 n1499__vddio vss 8.93986e-18
c4723 n227__i0__net2 vss 113.863e-18
c4724 n171__i0__i13__net1 vss 108.722e-18
c4725 n172__i0__i13__net1 vss 21.8135e-18
c4726 n173__i0__i13__net1 vss 18.4256e-18
c4727 n174__i0__i13__net1 vss 18.4256e-18
c4728 n175__i0__i13__net1 vss 18.4256e-18
c4729 n176__i0__i13__net1 vss 18.4256e-18
c4730 n177__i0__i13__net1 vss 18.4256e-18
c4731 n178__i0__i13__net1 vss 18.4256e-18
c4732 n179__i0__i13__net1 vss 18.4256e-18
c4733 n180__i0__i13__net1 vss 18.4402e-18
c4734 n181__i0__i13__net1 vss 18.4215e-18
c4735 n182__i0__i13__net1 vss 28.3813e-18
c4736 n1655__vddio vss 45.9538e-18
c4737 n53__i0__net3 vss 45.2184e-18
c4738 n56__i0__net3 vss 61.9296e-18
c4739 n63__i0__net3 vss 66.7593e-18
c4740 n70__i0__net3 vss 72.9432e-18
c4741 n75__i0__net3 vss 67.8238e-18
c4742 n59__i0__i12__net1 vss 59.9904e-18
c4743 n6__i0__i11__outinv vss 93.9133e-18
c4744 n1739__vddio vss 11.6783e-18
c4745 n1741__vddio vss 2.94352e-18
c4746 n1742__vddio vss 28.6923e-18
c4747 n1743__vddio vss 13.2817e-18
c4748 n1745__vddio vss 14.2299e-18
c4749 n1746__vddio vss 24.9776e-18
c4750 n1748__vddio vss 107.42e-18
c4751 n27__i0__net4 vss 80.5936e-18
c4752 n65__i0__i12__net1 vss 25.7203e-18
c4753 n66__i0__i12__net1 vss 26.4629e-18
rg2 n1321__vss n1323__vss 75.3e-3
rg4 n1323__vss vss 55.53e-3
rg5 vss n653__vss 19.77e-3
rg6 n653__vss n647__vss 4.708e-3
rg7 n649__vss n1321__vss 25e-3
rg8 n643__vss n1321__vss 4.167e-3
rg9 n651__vss n1323__vss 25e-3
rg10 n645__vss n1323__vss 4.167e-3
rh1 n5__r2 r2 43.12e-3
rh2 n1521__chipdriverout chipdriverout 2.651e-3
rh3 chipdriverout n1522__chipdriverout 88.61e-3
rh4 n1522__chipdriverout n1523__chipdriverout 172.3e-3
rh5 n1523__chipdriverout n1524__chipdriverout 92.39e-3
rh6 n1524__chipdriverout n1525__chipdriverout 87.85e-3
rh7 n1525__chipdriverout n1526__chipdriverout 92.39e-3
rh8 n1526__chipdriverout n1527__chipdriverout 87.85e-3
rh9 n1527__chipdriverout n1528__chipdriverout 91.64e-3
rh10 n1528__chipdriverout n1529__chipdriverout 88.61e-3
rh11 n1529__chipdriverout n1530__chipdriverout 141.3e-3
rh12 n1521__chipdriverout n1531__chipdriverout 91.26e-3
rh13 n1531__chipdriverout n1532__chipdriverout 85.96e-3
rh14 n1532__chipdriverout n1533__chipdriverout 140.9e-3
rh15 n3__r1 r1 41.25e-3
rh17 n643__vss n645__vss 139.2e-3
rh19 n645__vss n647__vss 139.2e-3
rh20 n647__vss n648__vss 4.167e-3
rh22 n649__vss n651__vss 1.05
rh24 n651__vss n637__vss 1.05
rh25 n637__vss n653__vss 25e-3
rh26 n632__vss n649__vss 25e-3
rh27 n634__vss n651__vss 25e-3
rh28 n38__s n41__s 2.489
rh29 n41__s n14__s 2.3334
rh30 n41__s n26__s 123.9e-3
rh31 n14__s n34__s 2.3888
rh32 n5__r0 r0 24.37e-3
rh33 n1326__i0__i14__net1 n1324__i0__i14__net1 115e-3
rh34 n1324__i0__i14__net1 n1327__i0__i14__net1 114e-3
rh35 n1327__i0__i14__net1 n1325__i0__i14__net1 116e-3
rh36 n1325__i0__i14__net1 n1328__i0__i14__net1 114e-3
rh37 n1328__i0__i14__net1 n777__i0__i14__net1 125.1e-3
rh38 n777__i0__i14__net1 n1329__i0__i14__net1 94.14e-3
rh39 n1329__i0__i14__net1 n1330__i0__i14__net1 114e-3
rh40 n1330__i0__i14__net1 n1331__i0__i14__net1 113.1e-3
rh41 n1331__i0__i14__net1 n1332__i0__i14__net1 114e-3
rh42 n1332__i0__i14__net1 n1333__i0__i14__net1 116.9e-3
rh43 n1333__i0__i14__net1 n1334__i0__i14__net1 116.9e-3
rh44 n1334__i0__i14__net1 n1335__i0__i14__net1 110.2e-3
rh45 n1335__i0__i14__net1 n1336__i0__i14__net1 119.8e-3
rh46 n15__reset n10__reset 2.3363
rh47 n10__reset _net0 2.2638
rh48 _net0 n5__reset 72.48e-3
rh49 n34__pinin n23__pinin 5.5923
rh50 n23__pinin n20__pinin 286.4e-3
rh51 n19__pinout n8__pinout 5.4787
ri1 n13__s n14__s 1
ri2 n8__i3__net10 n10__i3__net10 1.4496
ri3 n4__r2 n5__r2 500e-3
ri4 n15__i1__net3 n12__i1__net3 141.8e-3
ri5 n8__i3__net9 n7__i3__net9 1.7606
ri6 n3__reset n5__reset 500e-3
ri7 n25__i3__net13 n23__i3__net13 1.925
ri8 n8__i3__net12 n10__i3__net12 1.4496
ri9 n25__s n26__s 1
ri10 n7__i1__net4 n6__i1__net4 948.6e-3
ri11 n1__r1 n3__r1 500e-3
ri12 clk4 n12__clk4 2.053e-3
ri13 n13__clk4 n14__clk4 2.053e-3
ri14 n12__clk4 n13__clk4 55.02e-3
ri15 n11__i3__net11 n7__i3__net11 1.2606
ri16 n15__i1__net5 n12__i1__net5 641.8e-3
ri17 n34__s n32__s 270.8e-3
ri19 n632__vss n634__vss 1.059
ri21 n634__vss n636__vss 1.059
ri22 n636__vss n637__vss 25e-3
ri23 n618__vss n632__vss 25e-3
ri24 n620__vss n634__vss 25e-3
ri25 n622__vss n636__vss 25e-3
ri26 n8__reset n10__reset 500e-3
ri27 n37__s n38__s 1
ri28 n7__i1__net6 n6__i1__net6 948.6e-3
ri29 n1911__chipdriverout n1872__chipdriverout 82.51e-3
ri30 n1872__chipdriverout n1807__chipdriverout 82.51e-3
ri31 n1807__chipdriverout n1794__chipdriverout 81.33e-3
ri32 n1794__chipdriverout n1730__chipdriverout 83.69e-3
ri33 n1730__chipdriverout n1716__chipdriverout 82.51e-3
ri34 n1716__chipdriverout n1677__chipdriverout 81.33e-3
ri35 n1677__chipdriverout n1638__chipdriverout 82.51e-3
ri36 n1638__chipdriverout n1599__chipdriverout 81.33e-3
ri37 n1599__chipdriverout n1560__chipdriverout 82.51e-3
ri38 n1560__chipdriverout n1508__chipdriverout 82.51e-3
ri39 n1508__chipdriverout n1469__chipdriverout 82.51e-3
ri40 n1469__chipdriverout n1533__chipdriverout 44.2e-3
ri41 n1533__chipdriverout n1430__chipdriverout 38.31e-3
ri42 n1430__chipdriverout n1391__chipdriverout 82.51e-3
ri43 n1391__chipdriverout n1352__chipdriverout 82.51e-3
ri44 n1352__chipdriverout n1287__chipdriverout 84.87e-3
ri45 n1287__chipdriverout n1274__chipdriverout 81.33e-3
ri46 n1274__chipdriverout n1235__chipdriverout 81.33e-3
ri47 n1235__chipdriverout n1196__chipdriverout 82.51e-3
ri48 n1196__chipdriverout n1132__chipdriverout 84.87e-3
ri49 n1132__chipdriverout n1093__chipdriverout 82.51e-3
ri50 n1093__chipdriverout n1079__chipdriverout 80.16e-3
ri51 n1079__chipdriverout n1040__chipdriverout 82.51e-3
ri52 n1040__chipdriverout n1001__chipdriverout 84.87e-3
ri53 n1001__chipdriverout n962__chipdriverout 81.33e-3
ri54 n962__chipdriverout n898__chipdriverout 83.69e-3
ri55 n898__chipdriverout n892__chipdriverout 81.33e-3
ri56 n892__chipdriverout n845__chipdriverout 82.51e-3
ri57 n845__chipdriverout n806__chipdriverout 82.51e-3
ri58 n806__chipdriverout n767__chipdriverout 82.51e-3
ri59 n767__chipdriverout n703__chipdriverout 84.87e-3
ri60 n703__chipdriverout n664__chipdriverout 81.33e-3
ri61 n664__chipdriverout n625__chipdriverout 82.51e-3
ri62 n625__chipdriverout n586__chipdriverout 82.51e-3
ri63 n586__chipdriverout n547__chipdriverout 82.51e-3
ri64 n547__chipdriverout n508__chipdriverout 82.51e-3
ri65 n508__chipdriverout n469__chipdriverout 82.51e-3
ri66 n469__chipdriverout n455__chipdriverout 83.69e-3
ri67 n455__chipdriverout n416__chipdriverout 80.16e-3
ri68 n416__chipdriverout n377__chipdriverout 82.51e-3
ri69 n377__chipdriverout n338__chipdriverout 82.51e-3
ri70 n338__chipdriverout n299__chipdriverout 82.51e-3
ri71 n299__chipdriverout n260__chipdriverout 82.51e-3
ri72 n260__chipdriverout n221__chipdriverout 82.51e-3
ri73 n221__chipdriverout n182__chipdriverout 84.87e-3
ri74 n182__chipdriverout n143__chipdriverout 80.16e-3
ri75 n143__chipdriverout n104__chipdriverout 82.51e-3
ri76 n104__chipdriverout n65__chipdriverout 82.51e-3
ri77 n65__chipdriverout n26__chipdriverout 82.33e-3
ri78 n1912__chipdriverout n1873__chipdriverout 82.51e-3
ri79 n1873__chipdriverout n1810__chipdriverout 82.51e-3
ri80 n1810__chipdriverout n1795__chipdriverout 81.33e-3
ri81 n1795__chipdriverout n1731__chipdriverout 83.69e-3
ri82 n1731__chipdriverout n1717__chipdriverout 82.51e-3
ri83 n1717__chipdriverout n1678__chipdriverout 81.33e-3
ri84 n1678__chipdriverout n1639__chipdriverout 82.51e-3
ri85 n1639__chipdriverout n1600__chipdriverout 81.33e-3
ri86 n1600__chipdriverout n1561__chipdriverout 82.51e-3
ri87 n1561__chipdriverout n1509__chipdriverout 82.51e-3
ri88 n1509__chipdriverout n1470__chipdriverout 82.51e-3
ri89 n1470__chipdriverout n1924__chipdriverout 44.2e-3
ri90 n1924__chipdriverout n1431__chipdriverout 38.31e-3
ri91 n1431__chipdriverout n1392__chipdriverout 82.51e-3
ri92 n1392__chipdriverout n1353__chipdriverout 82.51e-3
ri93 n1353__chipdriverout n1290__chipdriverout 84.87e-3
ri94 n1290__chipdriverout n1275__chipdriverout 81.33e-3
ri95 n1275__chipdriverout n1236__chipdriverout 81.33e-3
ri96 n1236__chipdriverout n1197__chipdriverout 82.51e-3
ri97 n1197__chipdriverout n1133__chipdriverout 84.87e-3
ri98 n1133__chipdriverout n1094__chipdriverout 82.51e-3
ri99 n1094__chipdriverout n1080__chipdriverout 80.16e-3
ri100 n1080__chipdriverout n1041__chipdriverout 82.51e-3
ri101 n1041__chipdriverout n1002__chipdriverout 84.87e-3
ri102 n1002__chipdriverout n963__chipdriverout 81.33e-3
ri103 n963__chipdriverout n899__chipdriverout 83.69e-3
ri104 n899__chipdriverout n893__chipdriverout 81.33e-3
ri105 n893__chipdriverout n846__chipdriverout 82.51e-3
ri106 n846__chipdriverout n807__chipdriverout 82.51e-3
ri107 n807__chipdriverout n768__chipdriverout 82.51e-3
ri108 n768__chipdriverout n704__chipdriverout 84.87e-3
ri109 n704__chipdriverout n665__chipdriverout 81.33e-3
ri110 n665__chipdriverout n626__chipdriverout 82.51e-3
ri111 n626__chipdriverout n587__chipdriverout 82.51e-3
ri112 n587__chipdriverout n548__chipdriverout 82.51e-3
ri113 n548__chipdriverout n509__chipdriverout 82.51e-3
ri114 n509__chipdriverout n470__chipdriverout 82.51e-3
ri115 n470__chipdriverout n456__chipdriverout 83.69e-3
ri116 n456__chipdriverout n417__chipdriverout 80.16e-3
ri117 n417__chipdriverout n378__chipdriverout 82.51e-3
ri118 n378__chipdriverout n339__chipdriverout 82.51e-3
ri119 n339__chipdriverout n300__chipdriverout 82.51e-3
ri120 n300__chipdriverout n261__chipdriverout 82.51e-3
ri121 n261__chipdriverout n222__chipdriverout 82.51e-3
ri122 n222__chipdriverout n183__chipdriverout 84.87e-3
ri123 n183__chipdriverout n144__chipdriverout 80.16e-3
ri124 n144__chipdriverout n105__chipdriverout 82.51e-3
ri125 n105__chipdriverout n66__chipdriverout 82.51e-3
ri126 n66__chipdriverout n27__chipdriverout 82.51e-3
ri127 n1532__chipdriverout n1924__chipdriverout 50e-3
ri128 n1913__chipdriverout n1874__chipdriverout 82.51e-3
ri129 n1874__chipdriverout n1811__chipdriverout 82.51e-3
ri130 n1811__chipdriverout n1796__chipdriverout 81.33e-3
ri131 n1796__chipdriverout n1734__chipdriverout 83.69e-3
ri132 n1734__chipdriverout n1718__chipdriverout 82.51e-3
ri133 n1718__chipdriverout n1679__chipdriverout 81.33e-3
ri134 n1679__chipdriverout n1640__chipdriverout 82.51e-3
ri135 n1640__chipdriverout n1601__chipdriverout 81.33e-3
ri136 n1601__chipdriverout n1562__chipdriverout 82.51e-3
ri137 n1562__chipdriverout n1510__chipdriverout 82.51e-3
ri138 n1510__chipdriverout n1471__chipdriverout 82.51e-3
ri139 n1471__chipdriverout n1925__chipdriverout 44.2e-3
ri140 n1925__chipdriverout n1432__chipdriverout 38.31e-3
ri141 n1432__chipdriverout n1393__chipdriverout 82.51e-3
ri142 n1393__chipdriverout n1354__chipdriverout 82.51e-3
ri143 n1354__chipdriverout n1291__chipdriverout 84.87e-3
ri144 n1291__chipdriverout n1276__chipdriverout 81.33e-3
ri145 n1276__chipdriverout n1237__chipdriverout 81.33e-3
ri146 n1237__chipdriverout n1198__chipdriverout 82.51e-3
ri147 n1198__chipdriverout n1136__chipdriverout 84.87e-3
ri148 n1136__chipdriverout n1097__chipdriverout 82.51e-3
ri149 n1097__chipdriverout n1081__chipdriverout 80.16e-3
ri150 n1081__chipdriverout n1042__chipdriverout 82.51e-3
ri151 n1042__chipdriverout n1003__chipdriverout 84.87e-3
ri152 n1003__chipdriverout n964__chipdriverout 81.33e-3
ri153 n964__chipdriverout n902__chipdriverout 83.69e-3
ri154 n902__chipdriverout n894__chipdriverout 81.33e-3
ri155 n894__chipdriverout n847__chipdriverout 82.51e-3
ri156 n847__chipdriverout n808__chipdriverout 82.51e-3
ri157 n808__chipdriverout n769__chipdriverout 82.51e-3
ri158 n769__chipdriverout n707__chipdriverout 84.87e-3
ri159 n707__chipdriverout n668__chipdriverout 81.33e-3
ri160 n668__chipdriverout n629__chipdriverout 82.51e-3
ri161 n629__chipdriverout n590__chipdriverout 82.51e-3
ri162 n590__chipdriverout n551__chipdriverout 82.51e-3
ri163 n551__chipdriverout n512__chipdriverout 82.51e-3
ri164 n512__chipdriverout n473__chipdriverout 82.51e-3
ri165 n473__chipdriverout n457__chipdriverout 83.69e-3
ri166 n457__chipdriverout n418__chipdriverout 80.16e-3
ri167 n418__chipdriverout n379__chipdriverout 82.51e-3
ri168 n379__chipdriverout n340__chipdriverout 82.51e-3
ri169 n340__chipdriverout n301__chipdriverout 82.51e-3
ri170 n301__chipdriverout n262__chipdriverout 82.51e-3
ri171 n262__chipdriverout n223__chipdriverout 82.51e-3
ri172 n223__chipdriverout n184__chipdriverout 84.87e-3
ri173 n184__chipdriverout n145__chipdriverout 80.16e-3
ri174 n145__chipdriverout n106__chipdriverout 82.51e-3
ri175 n106__chipdriverout n67__chipdriverout 82.51e-3
ri176 n67__chipdriverout n28__chipdriverout 82.51e-3
ri177 n1531__chipdriverout n1925__chipdriverout 50e-3
ri178 n1914__chipdriverout n1875__chipdriverout 82.51e-3
ri179 n1875__chipdriverout n1814__chipdriverout 82.51e-3
ri180 n1814__chipdriverout n1797__chipdriverout 81.33e-3
ri181 n1797__chipdriverout n1735__chipdriverout 83.69e-3
ri182 n1735__chipdriverout n1719__chipdriverout 82.51e-3
ri183 n1719__chipdriverout n1680__chipdriverout 81.33e-3
ri184 n1680__chipdriverout n1641__chipdriverout 82.51e-3
ri185 n1641__chipdriverout n1602__chipdriverout 81.33e-3
ri186 n1602__chipdriverout n1563__chipdriverout 82.51e-3
ri187 n1563__chipdriverout n1511__chipdriverout 82.51e-3
ri188 n1511__chipdriverout n1472__chipdriverout 82.51e-3
ri189 n1472__chipdriverout n1926__chipdriverout 44.2e-3
ri190 n1926__chipdriverout n1433__chipdriverout 38.31e-3
ri191 n1433__chipdriverout n1394__chipdriverout 82.51e-3
ri192 n1394__chipdriverout n1355__chipdriverout 82.51e-3
ri193 n1355__chipdriverout n1294__chipdriverout 84.87e-3
ri194 n1294__chipdriverout n1277__chipdriverout 81.33e-3
ri195 n1277__chipdriverout n1238__chipdriverout 81.33e-3
ri196 n1238__chipdriverout n1199__chipdriverout 82.51e-3
ri197 n1199__chipdriverout n1137__chipdriverout 84.87e-3
ri198 n1137__chipdriverout n1098__chipdriverout 82.51e-3
ri199 n1098__chipdriverout n1082__chipdriverout 80.16e-3
ri200 n1082__chipdriverout n1043__chipdriverout 82.51e-3
ri201 n1043__chipdriverout n1004__chipdriverout 84.87e-3
ri202 n1004__chipdriverout n965__chipdriverout 81.33e-3
ri203 n965__chipdriverout n903__chipdriverout 83.69e-3
ri204 n903__chipdriverout n895__chipdriverout 81.33e-3
ri205 n895__chipdriverout n848__chipdriverout 82.51e-3
ri206 n848__chipdriverout n809__chipdriverout 82.51e-3
ri207 n809__chipdriverout n770__chipdriverout 82.51e-3
ri208 n770__chipdriverout n708__chipdriverout 84.87e-3
ri209 n708__chipdriverout n669__chipdriverout 81.33e-3
ri210 n669__chipdriverout n630__chipdriverout 82.51e-3
ri211 n630__chipdriverout n591__chipdriverout 82.51e-3
ri212 n591__chipdriverout n552__chipdriverout 82.51e-3
ri213 n552__chipdriverout n513__chipdriverout 82.51e-3
ri214 n513__chipdriverout n474__chipdriverout 82.51e-3
ri215 n474__chipdriverout n458__chipdriverout 83.69e-3
ri216 n458__chipdriverout n419__chipdriverout 80.16e-3
ri217 n419__chipdriverout n380__chipdriverout 82.51e-3
ri218 n380__chipdriverout n341__chipdriverout 82.51e-3
ri219 n341__chipdriverout n302__chipdriverout 82.51e-3
ri220 n302__chipdriverout n263__chipdriverout 82.51e-3
ri221 n263__chipdriverout n224__chipdriverout 82.51e-3
ri222 n224__chipdriverout n185__chipdriverout 84.87e-3
ri223 n185__chipdriverout n146__chipdriverout 80.16e-3
ri224 n146__chipdriverout n107__chipdriverout 82.51e-3
ri225 n107__chipdriverout n68__chipdriverout 82.51e-3
ri226 n68__chipdriverout n29__chipdriverout 82.51e-3
ri227 n1521__chipdriverout n1926__chipdriverout 50e-3
ri228 n1915__chipdriverout n1876__chipdriverout 82.51e-3
ri229 n1876__chipdriverout n1815__chipdriverout 82.51e-3
ri230 n1815__chipdriverout n1798__chipdriverout 81.33e-3
ri231 n1798__chipdriverout n1738__chipdriverout 83.69e-3
ri232 n1738__chipdriverout n1720__chipdriverout 82.51e-3
ri233 n1720__chipdriverout n1681__chipdriverout 81.33e-3
ri234 n1681__chipdriverout n1642__chipdriverout 82.51e-3
ri235 n1642__chipdriverout n1603__chipdriverout 81.33e-3
ri236 n1603__chipdriverout n1564__chipdriverout 82.51e-3
ri237 n1564__chipdriverout n1512__chipdriverout 82.51e-3
ri238 n1512__chipdriverout n1473__chipdriverout 82.51e-3
ri239 n1473__chipdriverout n1927__chipdriverout 44.2e-3
ri240 n1927__chipdriverout n1434__chipdriverout 38.31e-3
ri241 n1434__chipdriverout n1395__chipdriverout 82.51e-3
ri242 n1395__chipdriverout n1356__chipdriverout 82.51e-3
ri243 n1356__chipdriverout n1295__chipdriverout 84.87e-3
ri244 n1295__chipdriverout n1278__chipdriverout 81.33e-3
ri245 n1278__chipdriverout n1239__chipdriverout 81.33e-3
ri246 n1239__chipdriverout n1200__chipdriverout 82.51e-3
ri247 n1200__chipdriverout n1140__chipdriverout 84.87e-3
ri248 n1140__chipdriverout n1101__chipdriverout 82.51e-3
ri249 n1101__chipdriverout n1083__chipdriverout 80.16e-3
ri250 n1083__chipdriverout n1044__chipdriverout 82.51e-3
ri251 n1044__chipdriverout n1005__chipdriverout 84.87e-3
ri252 n1005__chipdriverout n966__chipdriverout 81.33e-3
ri253 n966__chipdriverout n906__chipdriverout 83.69e-3
ri254 n906__chipdriverout n896__chipdriverout 81.33e-3
ri255 n896__chipdriverout n849__chipdriverout 82.51e-3
ri256 n849__chipdriverout n810__chipdriverout 82.51e-3
ri257 n810__chipdriverout n771__chipdriverout 82.51e-3
ri258 n771__chipdriverout n711__chipdriverout 84.87e-3
ri259 n711__chipdriverout n672__chipdriverout 81.33e-3
ri260 n672__chipdriverout n633__chipdriverout 82.51e-3
ri261 n633__chipdriverout n594__chipdriverout 82.51e-3
ri262 n594__chipdriverout n555__chipdriverout 82.51e-3
ri263 n555__chipdriverout n516__chipdriverout 82.51e-3
ri264 n516__chipdriverout n477__chipdriverout 82.51e-3
ri265 n477__chipdriverout n459__chipdriverout 83.69e-3
ri266 n459__chipdriverout n420__chipdriverout 80.16e-3
ri267 n420__chipdriverout n381__chipdriverout 82.51e-3
ri268 n381__chipdriverout n342__chipdriverout 82.51e-3
ri269 n342__chipdriverout n303__chipdriverout 82.51e-3
ri270 n303__chipdriverout n264__chipdriverout 82.51e-3
ri271 n264__chipdriverout n225__chipdriverout 82.51e-3
ri272 n225__chipdriverout n186__chipdriverout 84.87e-3
ri273 n186__chipdriverout n147__chipdriverout 80.16e-3
ri274 n147__chipdriverout n108__chipdriverout 82.51e-3
ri275 n108__chipdriverout n69__chipdriverout 82.51e-3
ri276 n69__chipdriverout n30__chipdriverout 82.51e-3
ri277 n1522__chipdriverout n1927__chipdriverout 50e-3
ri278 n1916__chipdriverout n1877__chipdriverout 82.51e-3
ri279 n1877__chipdriverout n1838__chipdriverout 80.16e-3
ri280 n1838__chipdriverout n1799__chipdriverout 83.69e-3
ri281 n1799__chipdriverout n1739__chipdriverout 83.69e-3
ri282 n1739__chipdriverout n1721__chipdriverout 82.51e-3
ri283 n1721__chipdriverout n1682__chipdriverout 81.33e-3
ri284 n1682__chipdriverout n1643__chipdriverout 82.51e-3
ri285 n1643__chipdriverout n1604__chipdriverout 81.33e-3
ri286 n1604__chipdriverout n1565__chipdriverout 82.51e-3
ri287 n1565__chipdriverout n1513__chipdriverout 82.51e-3
ri288 n1513__chipdriverout n1474__chipdriverout 82.51e-3
ri289 n1474__chipdriverout n1928__chipdriverout 44.2e-3
ri290 n1928__chipdriverout n1435__chipdriverout 38.31e-3
ri291 n1435__chipdriverout n1396__chipdriverout 82.51e-3
ri292 n1396__chipdriverout n1357__chipdriverout 82.51e-3
ri293 n1357__chipdriverout n1298__chipdriverout 84.87e-3
ri294 n1298__chipdriverout n1279__chipdriverout 81.33e-3
ri295 n1279__chipdriverout n1240__chipdriverout 81.33e-3
ri296 n1240__chipdriverout n1201__chipdriverout 82.51e-3
ri297 n1201__chipdriverout n1141__chipdriverout 84.87e-3
ri298 n1141__chipdriverout n1102__chipdriverout 82.51e-3
ri299 n1102__chipdriverout n1084__chipdriverout 80.16e-3
ri300 n1084__chipdriverout n1045__chipdriverout 82.51e-3
ri301 n1045__chipdriverout n1006__chipdriverout 84.87e-3
ri302 n1006__chipdriverout n967__chipdriverout 81.33e-3
ri303 n967__chipdriverout n907__chipdriverout 83.69e-3
ri304 n907__chipdriverout n858__chipdriverout 83.69e-3
ri305 n858__chipdriverout n850__chipdriverout 80.16e-3
ri306 n850__chipdriverout n811__chipdriverout 82.51e-3
ri307 n811__chipdriverout n772__chipdriverout 82.51e-3
ri308 n772__chipdriverout n712__chipdriverout 84.87e-3
ri309 n712__chipdriverout n673__chipdriverout 81.33e-3
ri310 n673__chipdriverout n634__chipdriverout 82.51e-3
ri311 n634__chipdriverout n595__chipdriverout 82.51e-3
ri312 n595__chipdriverout n556__chipdriverout 82.51e-3
ri313 n556__chipdriverout n517__chipdriverout 82.51e-3
ri314 n517__chipdriverout n478__chipdriverout 82.51e-3
ri315 n478__chipdriverout n460__chipdriverout 83.69e-3
ri316 n460__chipdriverout n421__chipdriverout 80.16e-3
ri317 n421__chipdriverout n382__chipdriverout 82.51e-3
ri318 n382__chipdriverout n343__chipdriverout 82.51e-3
ri319 n343__chipdriverout n304__chipdriverout 82.51e-3
ri320 n304__chipdriverout n265__chipdriverout 82.51e-3
ri321 n265__chipdriverout n226__chipdriverout 82.51e-3
ri322 n226__chipdriverout n187__chipdriverout 84.87e-3
ri323 n187__chipdriverout n148__chipdriverout 80.16e-3
ri324 n148__chipdriverout n109__chipdriverout 82.51e-3
ri325 n109__chipdriverout n70__chipdriverout 82.51e-3
ri326 n70__chipdriverout n31__chipdriverout 82.51e-3
ri327 n1523__chipdriverout n1928__chipdriverout 50e-3
ri328 n1917__chipdriverout n1878__chipdriverout 82.51e-3
ri329 n1878__chipdriverout n1839__chipdriverout 80.16e-3
ri330 n1839__chipdriverout n1800__chipdriverout 83.69e-3
ri331 n1800__chipdriverout n1742__chipdriverout 83.69e-3
ri332 n1742__chipdriverout n1722__chipdriverout 82.51e-3
ri333 n1722__chipdriverout n1683__chipdriverout 81.33e-3
ri334 n1683__chipdriverout n1644__chipdriverout 82.51e-3
ri335 n1644__chipdriverout n1605__chipdriverout 81.33e-3
ri336 n1605__chipdriverout n1566__chipdriverout 82.51e-3
ri337 n1566__chipdriverout n1514__chipdriverout 82.51e-3
ri338 n1514__chipdriverout n1475__chipdriverout 82.51e-3
ri339 n1475__chipdriverout n1929__chipdriverout 44.2e-3
ri340 n1929__chipdriverout n1436__chipdriverout 38.31e-3
ri341 n1436__chipdriverout n1397__chipdriverout 82.51e-3
ri342 n1397__chipdriverout n1358__chipdriverout 82.51e-3
ri343 n1358__chipdriverout n1299__chipdriverout 84.87e-3
ri344 n1299__chipdriverout n1280__chipdriverout 81.33e-3
ri345 n1280__chipdriverout n1241__chipdriverout 81.33e-3
ri346 n1241__chipdriverout n1202__chipdriverout 82.51e-3
ri347 n1202__chipdriverout n1144__chipdriverout 84.87e-3
ri348 n1144__chipdriverout n1105__chipdriverout 82.51e-3
ri349 n1105__chipdriverout n1085__chipdriverout 80.16e-3
ri350 n1085__chipdriverout n1046__chipdriverout 82.51e-3
ri351 n1046__chipdriverout n1007__chipdriverout 84.87e-3
ri352 n1007__chipdriverout n968__chipdriverout 81.33e-3
ri353 n968__chipdriverout n910__chipdriverout 83.69e-3
ri354 n910__chipdriverout n861__chipdriverout 83.69e-3
ri355 n861__chipdriverout n851__chipdriverout 80.16e-3
ri356 n851__chipdriverout n812__chipdriverout 82.51e-3
ri357 n812__chipdriverout n773__chipdriverout 82.51e-3
ri358 n773__chipdriverout n715__chipdriverout 84.87e-3
ri359 n715__chipdriverout n676__chipdriverout 81.33e-3
ri360 n676__chipdriverout n637__chipdriverout 82.51e-3
ri361 n637__chipdriverout n598__chipdriverout 82.51e-3
ri362 n598__chipdriverout n559__chipdriverout 82.51e-3
ri363 n559__chipdriverout n520__chipdriverout 82.51e-3
ri364 n520__chipdriverout n481__chipdriverout 82.51e-3
ri365 n481__chipdriverout n461__chipdriverout 83.69e-3
ri366 n461__chipdriverout n422__chipdriverout 80.16e-3
ri367 n422__chipdriverout n383__chipdriverout 82.51e-3
ri368 n383__chipdriverout n344__chipdriverout 82.51e-3
ri369 n344__chipdriverout n305__chipdriverout 82.51e-3
ri370 n305__chipdriverout n266__chipdriverout 82.51e-3
ri371 n266__chipdriverout n227__chipdriverout 82.51e-3
ri372 n227__chipdriverout n188__chipdriverout 84.87e-3
ri373 n188__chipdriverout n149__chipdriverout 80.16e-3
ri374 n149__chipdriverout n110__chipdriverout 82.51e-3
ri375 n110__chipdriverout n71__chipdriverout 82.51e-3
ri376 n71__chipdriverout n32__chipdriverout 82.51e-3
ri377 n1524__chipdriverout n1929__chipdriverout 50e-3
ri378 n1918__chipdriverout n1879__chipdriverout 82.51e-3
ri379 n1879__chipdriverout n1840__chipdriverout 80.16e-3
ri380 n1840__chipdriverout n1801__chipdriverout 83.69e-3
ri381 n1801__chipdriverout n1743__chipdriverout 83.69e-3
ri382 n1743__chipdriverout n1723__chipdriverout 82.51e-3
ri383 n1723__chipdriverout n1684__chipdriverout 81.33e-3
ri384 n1684__chipdriverout n1645__chipdriverout 82.51e-3
ri385 n1645__chipdriverout n1606__chipdriverout 81.33e-3
ri386 n1606__chipdriverout n1567__chipdriverout 82.51e-3
ri387 n1567__chipdriverout n1515__chipdriverout 82.51e-3
ri388 n1515__chipdriverout n1476__chipdriverout 82.51e-3
ri389 n1476__chipdriverout n1930__chipdriverout 44.2e-3
ri390 n1930__chipdriverout n1437__chipdriverout 38.31e-3
ri391 n1437__chipdriverout n1398__chipdriverout 82.51e-3
ri392 n1398__chipdriverout n1359__chipdriverout 82.51e-3
ri393 n1359__chipdriverout n1302__chipdriverout 84.87e-3
ri394 n1302__chipdriverout n1281__chipdriverout 81.33e-3
ri395 n1281__chipdriverout n1242__chipdriverout 81.33e-3
ri396 n1242__chipdriverout n1203__chipdriverout 82.51e-3
ri397 n1203__chipdriverout n1145__chipdriverout 84.87e-3
ri398 n1145__chipdriverout n1106__chipdriverout 82.51e-3
ri399 n1106__chipdriverout n1086__chipdriverout 80.16e-3
ri400 n1086__chipdriverout n1047__chipdriverout 82.51e-3
ri401 n1047__chipdriverout n1008__chipdriverout 84.87e-3
ri402 n1008__chipdriverout n969__chipdriverout 81.33e-3
ri403 n969__chipdriverout n911__chipdriverout 83.69e-3
ri404 n911__chipdriverout n862__chipdriverout 83.69e-3
ri405 n862__chipdriverout n852__chipdriverout 80.16e-3
ri406 n852__chipdriverout n813__chipdriverout 82.51e-3
ri407 n813__chipdriverout n774__chipdriverout 82.51e-3
ri408 n774__chipdriverout n716__chipdriverout 84.87e-3
ri409 n716__chipdriverout n677__chipdriverout 81.33e-3
ri410 n677__chipdriverout n638__chipdriverout 82.51e-3
ri411 n638__chipdriverout n599__chipdriverout 82.51e-3
ri412 n599__chipdriverout n560__chipdriverout 82.51e-3
ri413 n560__chipdriverout n521__chipdriverout 82.51e-3
ri414 n521__chipdriverout n482__chipdriverout 82.51e-3
ri415 n482__chipdriverout n462__chipdriverout 83.69e-3
ri416 n462__chipdriverout n423__chipdriverout 80.16e-3
ri417 n423__chipdriverout n384__chipdriverout 82.51e-3
ri418 n384__chipdriverout n345__chipdriverout 82.51e-3
ri419 n345__chipdriverout n306__chipdriverout 82.51e-3
ri420 n306__chipdriverout n267__chipdriverout 82.51e-3
ri421 n267__chipdriverout n228__chipdriverout 82.51e-3
ri422 n228__chipdriverout n189__chipdriverout 84.87e-3
ri423 n189__chipdriverout n150__chipdriverout 80.16e-3
ri424 n150__chipdriverout n111__chipdriverout 82.51e-3
ri425 n111__chipdriverout n72__chipdriverout 82.51e-3
ri426 n72__chipdriverout n33__chipdriverout 82.51e-3
ri427 n1525__chipdriverout n1930__chipdriverout 50e-3
ri428 n1919__chipdriverout n1880__chipdriverout 82.51e-3
ri429 n1880__chipdriverout n1841__chipdriverout 80.16e-3
ri430 n1841__chipdriverout n1802__chipdriverout 83.69e-3
ri431 n1802__chipdriverout n1746__chipdriverout 83.69e-3
ri432 n1746__chipdriverout n1724__chipdriverout 82.51e-3
ri433 n1724__chipdriverout n1685__chipdriverout 81.33e-3
ri434 n1685__chipdriverout n1646__chipdriverout 82.51e-3
ri435 n1646__chipdriverout n1607__chipdriverout 81.33e-3
ri436 n1607__chipdriverout n1568__chipdriverout 82.51e-3
ri437 n1568__chipdriverout n1516__chipdriverout 82.51e-3
ri438 n1516__chipdriverout n1477__chipdriverout 82.51e-3
ri439 n1477__chipdriverout n1931__chipdriverout 44.2e-3
ri440 n1931__chipdriverout n1438__chipdriverout 38.31e-3
ri441 n1438__chipdriverout n1399__chipdriverout 82.51e-3
ri442 n1399__chipdriverout n1360__chipdriverout 82.51e-3
ri443 n1360__chipdriverout n1303__chipdriverout 84.87e-3
ri444 n1303__chipdriverout n1282__chipdriverout 81.33e-3
ri445 n1282__chipdriverout n1243__chipdriverout 81.33e-3
ri446 n1243__chipdriverout n1204__chipdriverout 82.51e-3
ri447 n1204__chipdriverout n1148__chipdriverout 84.87e-3
ri448 n1148__chipdriverout n1109__chipdriverout 82.51e-3
ri449 n1109__chipdriverout n1087__chipdriverout 80.16e-3
ri450 n1087__chipdriverout n1048__chipdriverout 82.51e-3
ri451 n1048__chipdriverout n1009__chipdriverout 84.87e-3
ri452 n1009__chipdriverout n970__chipdriverout 81.33e-3
ri453 n970__chipdriverout n914__chipdriverout 83.69e-3
ri454 n914__chipdriverout n865__chipdriverout 83.69e-3
ri455 n865__chipdriverout n853__chipdriverout 80.16e-3
ri456 n853__chipdriverout n814__chipdriverout 82.51e-3
ri457 n814__chipdriverout n775__chipdriverout 82.51e-3
ri458 n775__chipdriverout n719__chipdriverout 84.87e-3
ri459 n719__chipdriverout n680__chipdriverout 81.33e-3
ri460 n680__chipdriverout n641__chipdriverout 82.51e-3
ri461 n641__chipdriverout n602__chipdriverout 82.51e-3
ri462 n602__chipdriverout n563__chipdriverout 82.51e-3
ri463 n563__chipdriverout n524__chipdriverout 82.51e-3
ri464 n524__chipdriverout n485__chipdriverout 82.51e-3
ri465 n485__chipdriverout n463__chipdriverout 83.69e-3
ri466 n463__chipdriverout n424__chipdriverout 80.16e-3
ri467 n424__chipdriverout n385__chipdriverout 82.51e-3
ri468 n385__chipdriverout n346__chipdriverout 82.51e-3
ri469 n346__chipdriverout n307__chipdriverout 82.51e-3
ri470 n307__chipdriverout n268__chipdriverout 82.51e-3
ri471 n268__chipdriverout n229__chipdriverout 82.51e-3
ri472 n229__chipdriverout n190__chipdriverout 84.87e-3
ri473 n190__chipdriverout n151__chipdriverout 80.16e-3
ri474 n151__chipdriverout n112__chipdriverout 82.51e-3
ri475 n112__chipdriverout n73__chipdriverout 82.51e-3
ri476 n73__chipdriverout n34__chipdriverout 82.51e-3
ri477 n1526__chipdriverout n1931__chipdriverout 50e-3
ri478 n1920__chipdriverout n1881__chipdriverout 82.51e-3
ri479 n1881__chipdriverout n1842__chipdriverout 80.16e-3
ri480 n1842__chipdriverout n1803__chipdriverout 83.69e-3
ri481 n1803__chipdriverout n1747__chipdriverout 83.69e-3
ri482 n1747__chipdriverout n1725__chipdriverout 82.51e-3
ri483 n1725__chipdriverout n1686__chipdriverout 81.33e-3
ri484 n1686__chipdriverout n1647__chipdriverout 82.51e-3
ri485 n1647__chipdriverout n1608__chipdriverout 81.33e-3
ri486 n1608__chipdriverout n1569__chipdriverout 82.51e-3
ri487 n1569__chipdriverout n1517__chipdriverout 82.51e-3
ri488 n1517__chipdriverout n1478__chipdriverout 82.51e-3
ri489 n1478__chipdriverout n1932__chipdriverout 44.2e-3
ri490 n1932__chipdriverout n1439__chipdriverout 38.31e-3
ri491 n1439__chipdriverout n1400__chipdriverout 82.51e-3
ri492 n1400__chipdriverout n1361__chipdriverout 82.51e-3
ri493 n1361__chipdriverout n1306__chipdriverout 84.87e-3
ri494 n1306__chipdriverout n1283__chipdriverout 81.33e-3
ri495 n1283__chipdriverout n1244__chipdriverout 81.33e-3
ri496 n1244__chipdriverout n1205__chipdriverout 82.51e-3
ri497 n1205__chipdriverout n1149__chipdriverout 84.87e-3
ri498 n1149__chipdriverout n1110__chipdriverout 82.51e-3
ri499 n1110__chipdriverout n1088__chipdriverout 80.16e-3
ri500 n1088__chipdriverout n1049__chipdriverout 82.51e-3
ri501 n1049__chipdriverout n1010__chipdriverout 84.87e-3
ri502 n1010__chipdriverout n971__chipdriverout 81.33e-3
ri503 n971__chipdriverout n915__chipdriverout 83.69e-3
ri504 n915__chipdriverout n866__chipdriverout 83.69e-3
ri505 n866__chipdriverout n854__chipdriverout 80.16e-3
ri506 n854__chipdriverout n815__chipdriverout 82.51e-3
ri507 n815__chipdriverout n776__chipdriverout 82.51e-3
ri508 n776__chipdriverout n720__chipdriverout 84.87e-3
ri509 n720__chipdriverout n681__chipdriverout 81.33e-3
ri510 n681__chipdriverout n642__chipdriverout 82.51e-3
ri511 n642__chipdriverout n603__chipdriverout 82.51e-3
ri512 n603__chipdriverout n564__chipdriverout 82.51e-3
ri513 n564__chipdriverout n525__chipdriverout 82.51e-3
ri514 n525__chipdriverout n486__chipdriverout 82.51e-3
ri515 n486__chipdriverout n464__chipdriverout 83.69e-3
ri516 n464__chipdriverout n425__chipdriverout 80.16e-3
ri517 n425__chipdriverout n386__chipdriverout 82.51e-3
ri518 n386__chipdriverout n347__chipdriverout 82.51e-3
ri519 n347__chipdriverout n308__chipdriverout 82.51e-3
ri520 n308__chipdriverout n269__chipdriverout 82.51e-3
ri521 n269__chipdriverout n230__chipdriverout 82.51e-3
ri522 n230__chipdriverout n191__chipdriverout 84.87e-3
ri523 n191__chipdriverout n152__chipdriverout 80.16e-3
ri524 n152__chipdriverout n113__chipdriverout 82.51e-3
ri525 n113__chipdriverout n74__chipdriverout 82.51e-3
ri526 n74__chipdriverout n35__chipdriverout 82.51e-3
ri527 n1527__chipdriverout n1932__chipdriverout 50e-3
ri528 n1921__chipdriverout n1882__chipdriverout 82.51e-3
ri529 n1882__chipdriverout n1843__chipdriverout 80.16e-3
ri530 n1843__chipdriverout n1804__chipdriverout 83.69e-3
ri531 n1804__chipdriverout n1750__chipdriverout 83.69e-3
ri532 n1750__chipdriverout n1726__chipdriverout 82.51e-3
ri533 n1726__chipdriverout n1687__chipdriverout 81.33e-3
ri534 n1687__chipdriverout n1648__chipdriverout 82.51e-3
ri535 n1648__chipdriverout n1609__chipdriverout 81.33e-3
ri536 n1609__chipdriverout n1570__chipdriverout 82.51e-3
ri537 n1570__chipdriverout n1518__chipdriverout 82.51e-3
ri538 n1518__chipdriverout n1479__chipdriverout 82.51e-3
ri539 n1479__chipdriverout n1933__chipdriverout 44.2e-3
ri540 n1933__chipdriverout n1440__chipdriverout 38.31e-3
ri541 n1440__chipdriverout n1401__chipdriverout 82.51e-3
ri542 n1401__chipdriverout n1362__chipdriverout 82.51e-3
ri543 n1362__chipdriverout n1307__chipdriverout 84.87e-3
ri544 n1307__chipdriverout n1284__chipdriverout 81.33e-3
ri545 n1284__chipdriverout n1245__chipdriverout 81.33e-3
ri546 n1245__chipdriverout n1206__chipdriverout 82.51e-3
ri547 n1206__chipdriverout n1152__chipdriverout 84.87e-3
ri548 n1152__chipdriverout n1113__chipdriverout 82.51e-3
ri549 n1113__chipdriverout n1089__chipdriverout 80.16e-3
ri550 n1089__chipdriverout n1050__chipdriverout 82.51e-3
ri551 n1050__chipdriverout n1011__chipdriverout 84.87e-3
ri552 n1011__chipdriverout n972__chipdriverout 81.33e-3
ri553 n972__chipdriverout n918__chipdriverout 83.69e-3
ri554 n918__chipdriverout n869__chipdriverout 83.69e-3
ri555 n869__chipdriverout n855__chipdriverout 80.16e-3
ri556 n855__chipdriverout n816__chipdriverout 82.51e-3
ri557 n816__chipdriverout n777__chipdriverout 82.51e-3
ri558 n777__chipdriverout n723__chipdriverout 84.87e-3
ri559 n723__chipdriverout n684__chipdriverout 81.33e-3
ri560 n684__chipdriverout n645__chipdriverout 82.51e-3
ri561 n645__chipdriverout n606__chipdriverout 82.51e-3
ri562 n606__chipdriverout n567__chipdriverout 82.51e-3
ri563 n567__chipdriverout n528__chipdriverout 82.51e-3
ri564 n528__chipdriverout n489__chipdriverout 82.51e-3
ri565 n489__chipdriverout n465__chipdriverout 83.69e-3
ri566 n465__chipdriverout n426__chipdriverout 80.16e-3
ri567 n426__chipdriverout n387__chipdriverout 82.51e-3
ri568 n387__chipdriverout n348__chipdriverout 82.51e-3
ri569 n348__chipdriverout n309__chipdriverout 82.51e-3
ri570 n309__chipdriverout n270__chipdriverout 82.51e-3
ri571 n270__chipdriverout n231__chipdriverout 82.51e-3
ri572 n231__chipdriverout n192__chipdriverout 84.87e-3
ri573 n192__chipdriverout n153__chipdriverout 80.16e-3
ri574 n153__chipdriverout n114__chipdriverout 82.51e-3
ri575 n114__chipdriverout n75__chipdriverout 82.51e-3
ri576 n75__chipdriverout n36__chipdriverout 82.51e-3
ri577 n1528__chipdriverout n1933__chipdriverout 50e-3
ri578 n1922__chipdriverout n1883__chipdriverout 82.51e-3
ri579 n1883__chipdriverout n1844__chipdriverout 80.16e-3
ri580 n1844__chipdriverout n1805__chipdriverout 83.69e-3
ri581 n1805__chipdriverout n1751__chipdriverout 83.69e-3
ri582 n1751__chipdriverout n1727__chipdriverout 82.51e-3
ri583 n1727__chipdriverout n1688__chipdriverout 81.33e-3
ri584 n1688__chipdriverout n1649__chipdriverout 82.51e-3
ri585 n1649__chipdriverout n1610__chipdriverout 81.33e-3
ri586 n1610__chipdriverout n1571__chipdriverout 82.51e-3
ri587 n1571__chipdriverout n1519__chipdriverout 82.51e-3
ri588 n1519__chipdriverout n1480__chipdriverout 82.51e-3
ri589 n1480__chipdriverout n1934__chipdriverout 44.2e-3
ri590 n1934__chipdriverout n1441__chipdriverout 38.31e-3
ri591 n1441__chipdriverout n1402__chipdriverout 82.51e-3
ri592 n1402__chipdriverout n1363__chipdriverout 82.51e-3
ri593 n1363__chipdriverout n1310__chipdriverout 84.87e-3
ri594 n1310__chipdriverout n1285__chipdriverout 81.33e-3
ri595 n1285__chipdriverout n1246__chipdriverout 81.33e-3
ri596 n1246__chipdriverout n1207__chipdriverout 82.51e-3
ri597 n1207__chipdriverout n1153__chipdriverout 84.87e-3
ri598 n1153__chipdriverout n1114__chipdriverout 82.51e-3
ri599 n1114__chipdriverout n1090__chipdriverout 80.16e-3
ri600 n1090__chipdriverout n1051__chipdriverout 82.51e-3
ri601 n1051__chipdriverout n1012__chipdriverout 84.87e-3
ri602 n1012__chipdriverout n973__chipdriverout 81.33e-3
ri603 n973__chipdriverout n919__chipdriverout 83.69e-3
ri604 n919__chipdriverout n870__chipdriverout 83.69e-3
ri605 n870__chipdriverout n856__chipdriverout 80.16e-3
ri606 n856__chipdriverout n817__chipdriverout 82.51e-3
ri607 n817__chipdriverout n778__chipdriverout 82.51e-3
ri608 n778__chipdriverout n724__chipdriverout 84.87e-3
ri609 n724__chipdriverout n685__chipdriverout 81.33e-3
ri610 n685__chipdriverout n646__chipdriverout 82.51e-3
ri611 n646__chipdriverout n607__chipdriverout 82.51e-3
ri612 n607__chipdriverout n568__chipdriverout 82.51e-3
ri613 n568__chipdriverout n529__chipdriverout 82.51e-3
ri614 n529__chipdriverout n490__chipdriverout 82.51e-3
ri615 n490__chipdriverout n466__chipdriverout 83.69e-3
ri616 n466__chipdriverout n427__chipdriverout 80.16e-3
ri617 n427__chipdriverout n388__chipdriverout 82.51e-3
ri618 n388__chipdriverout n349__chipdriverout 82.51e-3
ri619 n349__chipdriverout n310__chipdriverout 82.51e-3
ri620 n310__chipdriverout n271__chipdriverout 82.51e-3
ri621 n271__chipdriverout n232__chipdriverout 82.51e-3
ri622 n232__chipdriverout n193__chipdriverout 84.87e-3
ri623 n193__chipdriverout n154__chipdriverout 80.16e-3
ri624 n154__chipdriverout n115__chipdriverout 82.51e-3
ri625 n115__chipdriverout n76__chipdriverout 82.51e-3
ri626 n76__chipdriverout n37__chipdriverout 82.51e-3
ri627 n1529__chipdriverout n1934__chipdriverout 50e-3
ri628 n1923__chipdriverout n1884__chipdriverout 82.51e-3
ri629 n1884__chipdriverout n1845__chipdriverout 80.16e-3
ri630 n1845__chipdriverout n1806__chipdriverout 83.69e-3
ri631 n1806__chipdriverout n1754__chipdriverout 83.69e-3
ri632 n1754__chipdriverout n1728__chipdriverout 82.51e-3
ri633 n1728__chipdriverout n1689__chipdriverout 81.33e-3
ri634 n1689__chipdriverout n1650__chipdriverout 82.51e-3
ri635 n1650__chipdriverout n1611__chipdriverout 81.33e-3
ri636 n1611__chipdriverout n1572__chipdriverout 82.51e-3
ri637 n1572__chipdriverout n1520__chipdriverout 82.51e-3
ri638 n1520__chipdriverout n1481__chipdriverout 82.51e-3
ri639 n1481__chipdriverout n1530__chipdriverout 44.2e-3
ri640 n1530__chipdriverout n1442__chipdriverout 38.31e-3
ri641 n1442__chipdriverout n1403__chipdriverout 82.51e-3
ri642 n1403__chipdriverout n1364__chipdriverout 82.51e-3
ri643 n1364__chipdriverout n1311__chipdriverout 84.87e-3
ri644 n1311__chipdriverout n1286__chipdriverout 81.33e-3
ri645 n1286__chipdriverout n1247__chipdriverout 81.33e-3
ri646 n1247__chipdriverout n1208__chipdriverout 82.51e-3
ri647 n1208__chipdriverout n1156__chipdriverout 84.87e-3
ri648 n1156__chipdriverout n1117__chipdriverout 82.51e-3
ri649 n1117__chipdriverout n1091__chipdriverout 80.16e-3
ri650 n1091__chipdriverout n1052__chipdriverout 82.51e-3
ri651 n1052__chipdriverout n1013__chipdriverout 84.87e-3
ri652 n1013__chipdriverout n974__chipdriverout 81.33e-3
ri653 n974__chipdriverout n922__chipdriverout 83.69e-3
ri654 n922__chipdriverout n873__chipdriverout 83.69e-3
ri655 n873__chipdriverout n857__chipdriverout 80.16e-3
ri656 n857__chipdriverout n818__chipdriverout 82.51e-3
ri657 n818__chipdriverout n779__chipdriverout 82.51e-3
ri658 n779__chipdriverout n727__chipdriverout 84.87e-3
ri659 n727__chipdriverout n688__chipdriverout 81.33e-3
ri660 n688__chipdriverout n649__chipdriverout 82.51e-3
ri661 n649__chipdriverout n610__chipdriverout 82.51e-3
ri662 n610__chipdriverout n571__chipdriverout 82.51e-3
ri663 n571__chipdriverout n532__chipdriverout 82.51e-3
ri664 n532__chipdriverout n493__chipdriverout 82.51e-3
ri665 n493__chipdriverout n467__chipdriverout 83.69e-3
ri666 n467__chipdriverout n428__chipdriverout 80.16e-3
ri667 n428__chipdriverout n389__chipdriverout 82.51e-3
ri668 n389__chipdriverout n350__chipdriverout 82.51e-3
ri669 n350__chipdriverout n311__chipdriverout 82.51e-3
ri670 n311__chipdriverout n272__chipdriverout 82.51e-3
ri671 n272__chipdriverout n233__chipdriverout 82.51e-3
ri672 n233__chipdriverout n194__chipdriverout 84.87e-3
ri673 n194__chipdriverout n155__chipdriverout 80.16e-3
ri674 n155__chipdriverout n116__chipdriverout 82.51e-3
ri675 n116__chipdriverout n77__chipdriverout 82.51e-3
ri676 n77__chipdriverout n38__chipdriverout 82.51e-3
ri677 n4__r0 n5__r0 500e-3
ri678 n688__vss n694__vss 165.8e-3
ri679 n694__vss n695__vss 82.51e-3
ri680 n695__vss n696__vss 82.51e-3
ri681 n696__vss n697__vss 82.51e-3
ri682 n697__vss n698__vss 82.51e-3
ri683 n698__vss n699__vss 82.51e-3
ri684 n699__vss n700__vss 82.51e-3
ri685 n700__vss n701__vss 80.16e-3
ri686 n701__vss n702__vss 82.51e-3
ri687 n702__vss n703__vss 82.51e-3
ri688 n703__vss n704__vss 82.51e-3
ri689 n704__vss n705__vss 82.51e-3
ri690 n705__vss n706__vss 82.51e-3
ri691 n706__vss n707__vss 82.51e-3
ri692 n707__vss n708__vss 82.51e-3
ri693 n708__vss n709__vss 82.51e-3
ri694 n709__vss n710__vss 82.51e-3
ri695 n710__vss n711__vss 82.51e-3
ri696 n711__vss n712__vss 82.51e-3
ri697 n712__vss n713__vss 82.51e-3
ri698 n713__vss n714__vss 82.51e-3
ri699 n714__vss n715__vss 82.51e-3
ri700 n715__vss n716__vss 80.16e-3
ri701 n716__vss n717__vss 82.51e-3
ri702 n717__vss n718__vss 82.51e-3
ri703 n718__vss n719__vss 82.51e-3
ri704 n719__vss n720__vss 82.51e-3
ri705 n720__vss n721__vss 82.51e-3
ri706 n721__vss n722__vss 82.51e-3
ri707 n722__vss n723__vss 88.41e-3
ri708 n723__vss n724__vss 82.51e-3
ri709 n724__vss n725__vss 82.51e-3
ri710 n725__vss n726__vss 82.51e-3
ri711 n726__vss n727__vss 82.51e-3
ri712 n727__vss n728__vss 82.51e-3
ri713 n728__vss n729__vss 82.51e-3
ri714 n729__vss n730__vss 82.51e-3
ri715 n730__vss n731__vss 80.16e-3
ri716 n731__vss n732__vss 82.51e-3
ri717 n732__vss n733__vss 82.51e-3
ri718 n733__vss n734__vss 82.51e-3
ri719 n734__vss n735__vss 82.51e-3
ri720 n735__vss n736__vss 82.51e-3
ri721 n736__vss n737__vss 82.51e-3
ri722 n737__vss n738__vss 82.51e-3
ri723 n738__vss n739__vss 82.51e-3
ri724 n739__vss n740__vss 82.51e-3
ri725 n740__vss n9__vss 165.8e-3
ri726 n689__vss n676__vss 82.51e-3
ri727 n676__vss n654__vss 80.16e-3
ri728 n654__vss n625__vss 83.69e-3
ri729 n625__vss n614__vss 83.69e-3
ri730 n614__vss n601__vss 82.51e-3
ri731 n601__vss n558__vss 81.33e-3
ri732 n558__vss n537__vss 82.51e-3
ri733 n537__vss n532__vss 81.33e-3
ri734 n532__vss n519__vss 82.51e-3
ri735 n519__vss n506__vss 82.51e-3
ri736 n506__vss n493__vss 82.51e-3
ri737 n493__vss n480__vss 82.51e-3
ri738 n480__vss n467__vss 82.51e-3
ri739 n467__vss n454__vss 82.51e-3
ri740 n454__vss n432__vss 84.87e-3
ri741 n432__vss n419__vss 81.33e-3
ri742 n419__vss n405__vss 81.33e-3
ri743 n405__vss n400__vss 82.51e-3
ri744 n400__vss n379__vss 84.87e-3
ri745 n379__vss n374__vss 82.51e-3
ri746 n374__vss n353__vss 80.16e-3
ri747 n353__vss n348__vss 82.51e-3
ri748 n348__vss n327__vss 84.87e-3
ri749 n327__vss n314__vss 81.33e-3
ri750 n314__vss n301__vss 83.69e-3
ri751 n301__vss n292__vss 78.98e-3
ri752 n292__vss n275__vss 84.87e-3
ri753 n275__vss n262__vss 82.51e-3
ri754 n262__vss n249__vss 82.51e-3
ri755 n249__vss n244__vss 84.87e-3
ri756 n244__vss n231__vss 81.33e-3
ri757 n231__vss n218__vss 82.51e-3
ri758 n218__vss n205__vss 82.51e-3
ri759 n205__vss n192__vss 82.51e-3
ri760 n192__vss n179__vss 82.51e-3
ri761 n179__vss n166__vss 82.51e-3
ri762 n166__vss n153__vss 83.69e-3
ri763 n153__vss n140__vss 80.16e-3
ri764 n140__vss n127__vss 82.51e-3
ri765 n127__vss n114__vss 82.51e-3
ri766 n114__vss n101__vss 82.51e-3
ri767 n101__vss n88__vss 82.51e-3
ri768 n88__vss n75__vss 82.51e-3
ri769 n75__vss n62__vss 82.51e-3
ri770 n62__vss n49__vss 82.51e-3
ri771 n49__vss n36__vss 82.51e-3
ri772 n36__vss n23__vss 82.51e-3
ri773 n23__vss n10__vss 82.51e-3
ri774 n690__vss n677__vss 82.51e-3
ri775 n677__vss n657__vss 80.16e-3
ri776 n657__vss n626__vss 83.69e-3
ri777 n626__vss n615__vss 83.69e-3
ri778 n615__vss n602__vss 82.51e-3
ri779 n602__vss n559__vss 81.33e-3
ri780 n559__vss n538__vss 82.51e-3
ri781 n538__vss n533__vss 81.33e-3
ri782 n533__vss n520__vss 82.51e-3
ri783 n520__vss n507__vss 82.51e-3
ri784 n507__vss n494__vss 82.51e-3
ri785 n494__vss n481__vss 82.51e-3
ri786 n481__vss n468__vss 82.51e-3
ri787 n468__vss n455__vss 82.51e-3
ri788 n455__vss n435__vss 84.87e-3
ri789 n435__vss n422__vss 81.33e-3
ri790 n422__vss n406__vss 81.33e-3
ri791 n406__vss n401__vss 82.51e-3
ri792 n401__vss n380__vss 84.87e-3
ri793 n380__vss n375__vss 82.51e-3
ri794 n375__vss n354__vss 80.16e-3
ri795 n354__vss n349__vss 82.51e-3
ri796 n349__vss n328__vss 84.87e-3
ri797 n328__vss n315__vss 81.33e-3
ri798 n315__vss n302__vss 83.69e-3
ri799 n302__vss n293__vss 78.98e-3
ri800 n293__vss n276__vss 84.87e-3
ri801 n276__vss n263__vss 82.51e-3
ri802 n263__vss n250__vss 82.51e-3
ri803 n250__vss n245__vss 84.87e-3
ri804 n245__vss n232__vss 81.33e-3
ri805 n232__vss n219__vss 82.51e-3
ri806 n219__vss n206__vss 82.51e-3
ri807 n206__vss n193__vss 82.51e-3
ri808 n193__vss n180__vss 82.51e-3
ri809 n180__vss n167__vss 82.51e-3
ri810 n167__vss n154__vss 83.69e-3
ri811 n154__vss n141__vss 80.16e-3
ri812 n141__vss n128__vss 82.51e-3
ri813 n128__vss n115__vss 82.51e-3
ri814 n115__vss n102__vss 82.51e-3
ri815 n102__vss n89__vss 82.51e-3
ri816 n89__vss n76__vss 82.51e-3
ri817 n76__vss n63__vss 82.51e-3
ri818 n63__vss n50__vss 82.51e-3
ri819 n50__vss n37__vss 82.51e-3
ri820 n37__vss n24__vss 82.51e-3
ri821 n24__vss n11__vss 82.51e-3
ri822 n691__vss n678__vss 82.51e-3
ri823 n678__vss n658__vss 80.16e-3
ri824 n658__vss n629__vss 83.69e-3
ri825 n629__vss n616__vss 83.69e-3
ri826 n616__vss n603__vss 82.51e-3
ri827 n603__vss n560__vss 81.33e-3
ri828 n560__vss n541__vss 82.51e-3
ri829 n541__vss n534__vss 81.33e-3
ri830 n534__vss n521__vss 82.51e-3
ri831 n521__vss n508__vss 82.51e-3
ri832 n508__vss n495__vss 82.51e-3
ri833 n495__vss n482__vss 82.51e-3
ri834 n482__vss n469__vss 82.51e-3
ri835 n469__vss n456__vss 82.51e-3
ri836 n456__vss n436__vss 84.87e-3
ri837 n436__vss n423__vss 81.33e-3
ri838 n423__vss n409__vss 81.33e-3
ri839 n409__vss n402__vss 82.51e-3
ri840 n402__vss n383__vss 84.87e-3
ri841 n383__vss n376__vss 82.51e-3
ri842 n376__vss n357__vss 80.16e-3
ri843 n357__vss n350__vss 82.51e-3
ri844 n350__vss n331__vss 84.87e-3
ri845 n331__vss n318__vss 81.33e-3
ri846 n318__vss n305__vss 83.69e-3
ri847 n305__vss n288__vss 80.16e-3
ri848 n288__vss n279__vss 83.69e-3
ri849 n279__vss n266__vss 82.51e-3
ri850 n266__vss n253__vss 82.51e-3
ri851 n253__vss n246__vss 84.87e-3
ri852 n246__vss n233__vss 81.33e-3
ri853 n233__vss n220__vss 82.51e-3
ri854 n220__vss n207__vss 82.51e-3
ri855 n207__vss n194__vss 82.51e-3
ri856 n194__vss n181__vss 82.51e-3
ri857 n181__vss n168__vss 82.51e-3
ri858 n168__vss n155__vss 83.69e-3
ri859 n155__vss n142__vss 80.16e-3
ri860 n142__vss n129__vss 82.51e-3
ri861 n129__vss n116__vss 82.51e-3
ri862 n116__vss n103__vss 82.51e-3
ri863 n103__vss n90__vss 82.51e-3
ri864 n90__vss n77__vss 82.51e-3
ri865 n77__vss n64__vss 82.51e-3
ri866 n64__vss n51__vss 82.51e-3
ri867 n51__vss n38__vss 82.51e-3
ri868 n38__vss n25__vss 82.51e-3
ri869 n25__vss n12__vss 82.51e-3
ri870 n692__vss n679__vss 82.51e-3
ri871 n679__vss n661__vss 80.16e-3
ri872 n661__vss n630__vss 83.69e-3
ri873 n630__vss n617__vss 83.69e-3
ri874 n617__vss n604__vss 82.51e-3
ri875 n604__vss n561__vss 81.33e-3
ri876 n561__vss n542__vss 82.51e-3
ri877 n542__vss n535__vss 81.33e-3
ri878 n535__vss n522__vss 82.51e-3
ri879 n522__vss n509__vss 82.51e-3
ri880 n509__vss n496__vss 82.51e-3
ri881 n496__vss n483__vss 82.51e-3
ri882 n483__vss n470__vss 82.51e-3
ri883 n470__vss n457__vss 82.51e-3
ri884 n457__vss n439__vss 84.87e-3
ri885 n439__vss n426__vss 81.33e-3
ri886 n426__vss n410__vss 81.33e-3
ri887 n410__vss n403__vss 82.51e-3
ri888 n403__vss n384__vss 84.87e-3
ri889 n384__vss n377__vss 82.51e-3
ri890 n377__vss n358__vss 80.16e-3
ri891 n358__vss n351__vss 82.51e-3
ri892 n351__vss n332__vss 84.87e-3
ri893 n332__vss n319__vss 81.33e-3
ri894 n319__vss n306__vss 83.69e-3
ri895 n306__vss n289__vss 80.16e-3
ri896 n289__vss n280__vss 83.69e-3
ri897 n280__vss n267__vss 82.51e-3
ri898 n267__vss n254__vss 82.51e-3
ri899 n254__vss n247__vss 84.87e-3
ri900 n247__vss n234__vss 81.33e-3
ri901 n234__vss n221__vss 82.51e-3
ri902 n221__vss n208__vss 82.51e-3
ri903 n208__vss n195__vss 82.51e-3
ri904 n195__vss n182__vss 82.51e-3
ri905 n182__vss n169__vss 82.51e-3
ri906 n169__vss n156__vss 83.69e-3
ri907 n156__vss n143__vss 80.16e-3
ri908 n143__vss n130__vss 82.51e-3
ri909 n130__vss n117__vss 82.51e-3
ri910 n117__vss n104__vss 82.51e-3
ri911 n104__vss n91__vss 82.51e-3
ri912 n91__vss n78__vss 82.51e-3
ri913 n78__vss n65__vss 82.51e-3
ri914 n65__vss n52__vss 82.51e-3
ri915 n52__vss n39__vss 82.51e-3
ri916 n39__vss n26__vss 82.51e-3
ri917 n26__vss n13__vss 82.51e-3
ri918 n1023__vddio n1002__vddio 82.51e-3
ri919 n1002__vddio n967__vddio 80.16e-3
ri920 n967__vddio n947__vddio 83.69e-3
ri921 n947__vddio n939__vddio 83.69e-3
ri922 n939__vddio n918__vddio 82.51e-3
ri923 n918__vddio n897__vddio 81.33e-3
ri924 n897__vddio n863__vddio 82.51e-3
ri925 n863__vddio n855__vddio 81.33e-3
ri926 n855__vddio n834__vddio 82.51e-3
ri927 n834__vddio n813__vddio 82.51e-3
ri928 n813__vddio n792__vddio 82.51e-3
ri929 n792__vddio n771__vddio 82.51e-3
ri930 n771__vddio n750__vddio 82.51e-3
ri931 n750__vddio n729__vddio 82.51e-3
ri932 n729__vddio n708__vddio 84.87e-3
ri933 n708__vddio n687__vddio 81.33e-3
ri934 n687__vddio n653__vddio 81.33e-3
ri935 n653__vddio n645__vddio 82.51e-3
ri936 n645__vddio n611__vddio 84.87e-3
ri937 n611__vddio n603__vddio 82.51e-3
ri938 n603__vddio n569__vddio 80.16e-3
ri939 n569__vddio n561__vddio 82.51e-3
ri940 n561__vddio n527__vddio 84.87e-3
ri941 n527__vddio n519__vddio 81.33e-3
ri942 n519__vddio n498__vddio 83.69e-3
ri943 n498__vddio n477__vddio 83.69e-3
ri944 n477__vddio n456__vddio 80.16e-3
ri945 n456__vddio n435__vddio 82.51e-3
ri946 n435__vddio n414__vddio 82.51e-3
ri947 n414__vddio n393__vddio 84.87e-3
ri948 n393__vddio n372__vddio 81.33e-3
ri949 n372__vddio n351__vddio 82.51e-3
ri950 n351__vddio n330__vddio 82.51e-3
ri951 n330__vddio n309__vddio 82.51e-3
ri952 n309__vddio n288__vddio 82.51e-3
ri953 n288__vddio n267__vddio 82.51e-3
ri954 n267__vddio n246__vddio 83.69e-3
ri955 n246__vddio n225__vddio 80.16e-3
ri956 n225__vddio n204__vddio 82.51e-3
ri957 n204__vddio n183__vddio 82.51e-3
ri958 n183__vddio n162__vddio 82.51e-3
ri959 n162__vddio n141__vddio 82.51e-3
ri960 n141__vddio n120__vddio 82.51e-3
ri961 n120__vddio n99__vddio 82.51e-3
ri962 n99__vddio n78__vddio 82.51e-3
ri963 n78__vddio n57__vddio 82.51e-3
ri964 n57__vddio n36__vddio 82.51e-3
ri965 n36__vddio n15__vddio 82.51e-3
ri966 n1024__vddio n1003__vddio 82.51e-3
ri967 n1003__vddio n970__vddio 80.16e-3
ri968 n970__vddio n948__vddio 83.69e-3
ri969 n948__vddio n940__vddio 83.69e-3
ri970 n940__vddio n919__vddio 82.51e-3
ri971 n919__vddio n898__vddio 81.33e-3
ri972 n898__vddio n864__vddio 82.51e-3
ri973 n864__vddio n856__vddio 81.33e-3
ri974 n856__vddio n835__vddio 82.51e-3
ri975 n835__vddio n814__vddio 82.51e-3
ri976 n814__vddio n793__vddio 82.51e-3
ri977 n793__vddio n772__vddio 82.51e-3
ri978 n772__vddio n751__vddio 82.51e-3
ri979 n751__vddio n730__vddio 82.51e-3
ri980 n730__vddio n709__vddio 84.87e-3
ri981 n709__vddio n688__vddio 81.33e-3
ri982 n688__vddio n654__vddio 81.33e-3
ri983 n654__vddio n646__vddio 82.51e-3
ri984 n646__vddio n612__vddio 84.87e-3
ri985 n612__vddio n604__vddio 82.51e-3
ri986 n604__vddio n570__vddio 80.16e-3
ri987 n570__vddio n562__vddio 82.51e-3
ri988 n562__vddio n528__vddio 84.87e-3
ri989 n528__vddio n520__vddio 81.33e-3
ri990 n520__vddio n499__vddio 83.69e-3
ri991 n499__vddio n478__vddio 83.69e-3
ri992 n478__vddio n457__vddio 80.16e-3
ri993 n457__vddio n436__vddio 82.51e-3
ri994 n436__vddio n415__vddio 82.51e-3
ri995 n415__vddio n394__vddio 84.87e-3
ri996 n394__vddio n373__vddio 81.33e-3
ri997 n373__vddio n352__vddio 82.51e-3
ri998 n352__vddio n331__vddio 82.51e-3
ri999 n331__vddio n310__vddio 82.51e-3
ri1000 n310__vddio n289__vddio 82.51e-3
ri1001 n289__vddio n268__vddio 82.51e-3
ri1002 n268__vddio n247__vddio 83.69e-3
ri1003 n247__vddio n226__vddio 80.16e-3
ri1004 n226__vddio n205__vddio 82.51e-3
ri1005 n205__vddio n184__vddio 82.51e-3
ri1006 n184__vddio n163__vddio 82.51e-3
ri1007 n163__vddio n142__vddio 82.51e-3
ri1008 n142__vddio n121__vddio 82.51e-3
ri1009 n121__vddio n100__vddio 82.51e-3
ri1010 n100__vddio n79__vddio 82.51e-3
ri1011 n79__vddio n58__vddio 82.51e-3
ri1012 n58__vddio n37__vddio 82.51e-3
ri1013 n37__vddio n16__vddio 82.51e-3
ri1014 n1025__vddio n1004__vddio 82.51e-3
ri1015 n1004__vddio n971__vddio 80.16e-3
ri1016 n971__vddio n951__vddio 83.69e-3
ri1017 n951__vddio n941__vddio 83.69e-3
ri1018 n941__vddio n920__vddio 82.51e-3
ri1019 n920__vddio n899__vddio 81.33e-3
ri1020 n899__vddio n867__vddio 82.51e-3
ri1021 n867__vddio n857__vddio 81.33e-3
ri1022 n857__vddio n836__vddio 82.51e-3
ri1023 n836__vddio n815__vddio 82.51e-3
ri1024 n815__vddio n794__vddio 82.51e-3
ri1025 n794__vddio n773__vddio 82.51e-3
ri1026 n773__vddio n752__vddio 82.51e-3
ri1027 n752__vddio n731__vddio 82.51e-3
ri1028 n731__vddio n710__vddio 84.87e-3
ri1029 n710__vddio n689__vddio 81.33e-3
ri1030 n689__vddio n657__vddio 81.33e-3
ri1031 n657__vddio n647__vddio 82.51e-3
ri1032 n647__vddio n615__vddio 84.87e-3
ri1033 n615__vddio n605__vddio 82.51e-3
ri1034 n605__vddio n573__vddio 80.16e-3
ri1035 n573__vddio n563__vddio 82.51e-3
ri1036 n563__vddio n531__vddio 84.87e-3
ri1037 n531__vddio n521__vddio 81.33e-3
ri1038 n521__vddio n500__vddio 83.69e-3
ri1039 n500__vddio n479__vddio 83.69e-3
ri1040 n479__vddio n458__vddio 80.16e-3
ri1041 n458__vddio n437__vddio 82.51e-3
ri1042 n437__vddio n416__vddio 82.51e-3
ri1043 n416__vddio n395__vddio 84.87e-3
ri1044 n395__vddio n374__vddio 81.33e-3
ri1045 n374__vddio n353__vddio 82.51e-3
ri1046 n353__vddio n332__vddio 82.51e-3
ri1047 n332__vddio n311__vddio 82.51e-3
ri1048 n311__vddio n290__vddio 82.51e-3
ri1049 n290__vddio n269__vddio 82.51e-3
ri1050 n269__vddio n248__vddio 83.69e-3
ri1051 n248__vddio n227__vddio 80.16e-3
ri1052 n227__vddio n206__vddio 82.51e-3
ri1053 n206__vddio n185__vddio 82.51e-3
ri1054 n185__vddio n164__vddio 82.51e-3
ri1055 n164__vddio n143__vddio 82.51e-3
ri1056 n143__vddio n122__vddio 82.51e-3
ri1057 n122__vddio n101__vddio 82.51e-3
ri1058 n101__vddio n80__vddio 82.51e-3
ri1059 n80__vddio n59__vddio 82.51e-3
ri1060 n59__vddio n38__vddio 82.51e-3
ri1061 n38__vddio n17__vddio 82.51e-3
ri1062 n1026__vddio n1005__vddio 82.51e-3
ri1063 n1005__vddio n974__vddio 80.16e-3
ri1064 n974__vddio n952__vddio 83.69e-3
ri1065 n952__vddio n942__vddio 83.69e-3
ri1066 n942__vddio n921__vddio 82.51e-3
ri1067 n921__vddio n900__vddio 81.33e-3
ri1068 n900__vddio n868__vddio 82.51e-3
ri1069 n868__vddio n858__vddio 81.33e-3
ri1070 n858__vddio n837__vddio 82.51e-3
ri1071 n837__vddio n816__vddio 82.51e-3
ri1072 n816__vddio n795__vddio 82.51e-3
ri1073 n795__vddio n774__vddio 82.51e-3
ri1074 n774__vddio n753__vddio 82.51e-3
ri1075 n753__vddio n732__vddio 82.51e-3
ri1076 n732__vddio n711__vddio 84.87e-3
ri1077 n711__vddio n690__vddio 81.33e-3
ri1078 n690__vddio n658__vddio 81.33e-3
ri1079 n658__vddio n648__vddio 82.51e-3
ri1080 n648__vddio n616__vddio 84.87e-3
ri1081 n616__vddio n606__vddio 82.51e-3
ri1082 n606__vddio n574__vddio 80.16e-3
ri1083 n574__vddio n564__vddio 82.51e-3
ri1084 n564__vddio n532__vddio 84.87e-3
ri1085 n532__vddio n522__vddio 81.33e-3
ri1086 n522__vddio n501__vddio 83.69e-3
ri1087 n501__vddio n480__vddio 83.69e-3
ri1088 n480__vddio n459__vddio 80.16e-3
ri1089 n459__vddio n438__vddio 82.51e-3
ri1090 n438__vddio n417__vddio 82.51e-3
ri1091 n417__vddio n396__vddio 84.87e-3
ri1092 n396__vddio n375__vddio 81.33e-3
ri1093 n375__vddio n354__vddio 82.51e-3
ri1094 n354__vddio n333__vddio 82.51e-3
ri1095 n333__vddio n312__vddio 82.51e-3
ri1096 n312__vddio n291__vddio 82.51e-3
ri1097 n291__vddio n270__vddio 82.51e-3
ri1098 n270__vddio n249__vddio 83.69e-3
ri1099 n249__vddio n228__vddio 80.16e-3
ri1100 n228__vddio n207__vddio 82.51e-3
ri1101 n207__vddio n186__vddio 82.51e-3
ri1102 n186__vddio n165__vddio 82.51e-3
ri1103 n165__vddio n144__vddio 82.51e-3
ri1104 n144__vddio n123__vddio 82.51e-3
ri1105 n123__vddio n102__vddio 82.51e-3
ri1106 n102__vddio n81__vddio 82.51e-3
ri1107 n81__vddio n60__vddio 82.51e-3
ri1108 n60__vddio n39__vddio 82.51e-3
ri1109 n39__vddio n18__vddio 82.51e-3
ri1110 n1027__vddio n1006__vddio 82.51e-3
ri1111 n1006__vddio n975__vddio 80.16e-3
ri1112 n975__vddio n955__vddio 83.69e-3
ri1113 n955__vddio n943__vddio 83.69e-3
ri1114 n943__vddio n922__vddio 82.51e-3
ri1115 n922__vddio n901__vddio 81.33e-3
ri1116 n901__vddio n871__vddio 82.51e-3
ri1117 n871__vddio n859__vddio 81.33e-3
ri1118 n859__vddio n838__vddio 82.51e-3
ri1119 n838__vddio n817__vddio 82.51e-3
ri1120 n817__vddio n796__vddio 82.51e-3
ri1121 n796__vddio n775__vddio 82.51e-3
ri1122 n775__vddio n754__vddio 82.51e-3
ri1123 n754__vddio n733__vddio 82.51e-3
ri1124 n733__vddio n712__vddio 84.87e-3
ri1125 n712__vddio n691__vddio 81.33e-3
ri1126 n691__vddio n661__vddio 81.33e-3
ri1127 n661__vddio n649__vddio 82.51e-3
ri1128 n649__vddio n619__vddio 84.87e-3
ri1129 n619__vddio n607__vddio 82.51e-3
ri1130 n607__vddio n577__vddio 80.16e-3
ri1131 n577__vddio n565__vddio 82.51e-3
ri1132 n565__vddio n535__vddio 84.87e-3
ri1133 n535__vddio n523__vddio 81.33e-3
ri1134 n523__vddio n502__vddio 83.69e-3
ri1135 n502__vddio n481__vddio 83.69e-3
ri1136 n481__vddio n460__vddio 80.16e-3
ri1137 n460__vddio n439__vddio 82.51e-3
ri1138 n439__vddio n418__vddio 82.51e-3
ri1139 n418__vddio n397__vddio 84.87e-3
ri1140 n397__vddio n376__vddio 81.33e-3
ri1141 n376__vddio n355__vddio 82.51e-3
ri1142 n355__vddio n334__vddio 82.51e-3
ri1143 n334__vddio n313__vddio 82.51e-3
ri1144 n313__vddio n292__vddio 82.51e-3
ri1145 n292__vddio n271__vddio 82.51e-3
ri1146 n271__vddio n250__vddio 83.69e-3
ri1147 n250__vddio n229__vddio 80.16e-3
ri1148 n229__vddio n208__vddio 82.51e-3
ri1149 n208__vddio n187__vddio 82.51e-3
ri1150 n187__vddio n166__vddio 82.51e-3
ri1151 n166__vddio n145__vddio 82.51e-3
ri1152 n145__vddio n124__vddio 82.51e-3
ri1153 n124__vddio n103__vddio 82.51e-3
ri1154 n103__vddio n82__vddio 82.51e-3
ri1155 n82__vddio n61__vddio 82.51e-3
ri1156 n61__vddio n40__vddio 82.51e-3
ri1157 n40__vddio n19__vddio 82.51e-3
ri1158 n1028__vddio n1007__vddio 82.51e-3
ri1159 n1007__vddio n978__vddio 80.16e-3
ri1160 n978__vddio n956__vddio 83.69e-3
ri1161 n956__vddio n944__vddio 83.69e-3
ri1162 n944__vddio n923__vddio 82.51e-3
ri1163 n923__vddio n902__vddio 81.33e-3
ri1164 n902__vddio n872__vddio 82.51e-3
ri1165 n872__vddio n860__vddio 81.33e-3
ri1166 n860__vddio n839__vddio 82.51e-3
ri1167 n839__vddio n818__vddio 82.51e-3
ri1168 n818__vddio n797__vddio 82.51e-3
ri1169 n797__vddio n776__vddio 82.51e-3
ri1170 n776__vddio n755__vddio 82.51e-3
ri1171 n755__vddio n734__vddio 82.51e-3
ri1172 n734__vddio n713__vddio 84.87e-3
ri1173 n713__vddio n692__vddio 81.33e-3
ri1174 n692__vddio n662__vddio 81.33e-3
ri1175 n662__vddio n650__vddio 82.51e-3
ri1176 n650__vddio n620__vddio 84.87e-3
ri1177 n620__vddio n608__vddio 82.51e-3
ri1178 n608__vddio n578__vddio 80.16e-3
ri1179 n578__vddio n566__vddio 82.51e-3
ri1180 n566__vddio n536__vddio 84.87e-3
ri1181 n536__vddio n524__vddio 81.33e-3
ri1182 n524__vddio n503__vddio 83.69e-3
ri1183 n503__vddio n482__vddio 83.69e-3
ri1184 n482__vddio n461__vddio 80.16e-3
ri1185 n461__vddio n440__vddio 82.51e-3
ri1186 n440__vddio n419__vddio 82.51e-3
ri1187 n419__vddio n398__vddio 84.87e-3
ri1188 n398__vddio n377__vddio 81.33e-3
ri1189 n377__vddio n356__vddio 82.51e-3
ri1190 n356__vddio n335__vddio 82.51e-3
ri1191 n335__vddio n314__vddio 82.51e-3
ri1192 n314__vddio n293__vddio 82.51e-3
ri1193 n293__vddio n272__vddio 82.51e-3
ri1194 n272__vddio n251__vddio 83.69e-3
ri1195 n251__vddio n230__vddio 80.16e-3
ri1196 n230__vddio n209__vddio 82.51e-3
ri1197 n209__vddio n188__vddio 82.51e-3
ri1198 n188__vddio n167__vddio 82.51e-3
ri1199 n167__vddio n146__vddio 82.51e-3
ri1200 n146__vddio n125__vddio 82.51e-3
ri1201 n125__vddio n104__vddio 82.51e-3
ri1202 n104__vddio n83__vddio 82.51e-3
ri1203 n83__vddio n62__vddio 82.51e-3
ri1204 n62__vddio n41__vddio 82.51e-3
ri1205 n41__vddio n20__vddio 82.51e-3
ri1206 n1029__vddio n1008__vddio 82.51e-3
ri1207 n1008__vddio n979__vddio 80.16e-3
ri1208 n979__vddio n959__vddio 83.69e-3
ri1209 n959__vddio n945__vddio 83.69e-3
ri1210 n945__vddio n924__vddio 82.51e-3
ri1211 n924__vddio n903__vddio 81.33e-3
ri1212 n903__vddio n875__vddio 82.51e-3
ri1213 n875__vddio n861__vddio 81.33e-3
ri1214 n861__vddio n840__vddio 82.51e-3
ri1215 n840__vddio n819__vddio 82.51e-3
ri1216 n819__vddio n798__vddio 82.51e-3
ri1217 n798__vddio n777__vddio 82.51e-3
ri1218 n777__vddio n756__vddio 82.51e-3
ri1219 n756__vddio n735__vddio 82.51e-3
ri1220 n735__vddio n714__vddio 84.87e-3
ri1221 n714__vddio n693__vddio 81.33e-3
ri1222 n693__vddio n665__vddio 81.33e-3
ri1223 n665__vddio n651__vddio 82.51e-3
ri1224 n651__vddio n623__vddio 84.87e-3
ri1225 n623__vddio n609__vddio 82.51e-3
ri1226 n609__vddio n581__vddio 80.16e-3
ri1227 n581__vddio n567__vddio 82.51e-3
ri1228 n567__vddio n539__vddio 84.87e-3
ri1229 n539__vddio n525__vddio 81.33e-3
ri1230 n525__vddio n504__vddio 83.69e-3
ri1231 n504__vddio n483__vddio 83.69e-3
ri1232 n483__vddio n462__vddio 80.16e-3
ri1233 n462__vddio n441__vddio 82.51e-3
ri1234 n441__vddio n420__vddio 82.51e-3
ri1235 n420__vddio n399__vddio 84.87e-3
ri1236 n399__vddio n378__vddio 81.33e-3
ri1237 n378__vddio n357__vddio 82.51e-3
ri1238 n357__vddio n336__vddio 82.51e-3
ri1239 n336__vddio n315__vddio 82.51e-3
ri1240 n315__vddio n294__vddio 82.51e-3
ri1241 n294__vddio n273__vddio 82.51e-3
ri1242 n273__vddio n252__vddio 83.69e-3
ri1243 n252__vddio n231__vddio 80.16e-3
ri1244 n231__vddio n210__vddio 82.51e-3
ri1245 n210__vddio n189__vddio 82.51e-3
ri1246 n189__vddio n168__vddio 82.51e-3
ri1247 n168__vddio n147__vddio 82.51e-3
ri1248 n147__vddio n126__vddio 82.51e-3
ri1249 n126__vddio n105__vddio 82.51e-3
ri1250 n105__vddio n84__vddio 82.51e-3
ri1251 n84__vddio n63__vddio 82.51e-3
ri1252 n63__vddio n42__vddio 82.51e-3
ri1253 n42__vddio n21__vddio 82.51e-3
ri1254 n1022__vddio n1031__vddio 165.8e-3
ri1255 n1031__vddio n1032__vddio 80.16e-3
ri1256 n1032__vddio n1033__vddio 83.69e-3
ri1257 n1033__vddio n1034__vddio 83.69e-3
ri1258 n1034__vddio n1035__vddio 82.51e-3
ri1259 n1035__vddio n1036__vddio 81.33e-3
ri1260 n1036__vddio n1037__vddio 82.51e-3
ri1261 n1037__vddio n1038__vddio 81.33e-3
ri1262 n1038__vddio n1039__vddio 82.51e-3
ri1263 n1039__vddio n1040__vddio 82.51e-3
ri1264 n1040__vddio n1041__vddio 82.51e-3
ri1265 n1041__vddio n1042__vddio 82.51e-3
ri1266 n1042__vddio n1043__vddio 82.51e-3
ri1267 n1043__vddio n1044__vddio 82.51e-3
ri1268 n1044__vddio n1045__vddio 84.87e-3
ri1269 n1045__vddio n1046__vddio 81.33e-3
ri1270 n1046__vddio n1047__vddio 81.33e-3
ri1271 n1047__vddio n1048__vddio 82.51e-3
ri1272 n1048__vddio n1049__vddio 84.87e-3
ri1273 n1049__vddio n1050__vddio 82.51e-3
ri1274 n1050__vddio n1051__vddio 80.16e-3
ri1275 n1051__vddio n1052__vddio 82.51e-3
ri1276 n1052__vddio n1053__vddio 84.87e-3
ri1277 n1053__vddio n1054__vddio 81.33e-3
ri1278 n1054__vddio n1055__vddio 83.69e-3
ri1279 n1055__vddio n1056__vddio 83.69e-3
ri1280 n1056__vddio n1057__vddio 80.16e-3
ri1281 n1057__vddio n1058__vddio 82.51e-3
ri1282 n1058__vddio n1059__vddio 82.51e-3
ri1283 n1059__vddio n1060__vddio 84.87e-3
ri1284 n1060__vddio n1061__vddio 81.33e-3
ri1285 n1061__vddio n1062__vddio 82.51e-3
ri1286 n1062__vddio n1063__vddio 82.51e-3
ri1287 n1063__vddio n1064__vddio 82.51e-3
ri1288 n1064__vddio n1065__vddio 82.51e-3
ri1289 n1065__vddio n1066__vddio 82.51e-3
ri1290 n1066__vddio n1067__vddio 83.69e-3
ri1291 n1067__vddio n1068__vddio 80.16e-3
ri1292 n1068__vddio n1069__vddio 82.51e-3
ri1293 n1069__vddio n1070__vddio 82.51e-3
ri1294 n1070__vddio n1071__vddio 82.51e-3
ri1295 n1071__vddio n1072__vddio 82.51e-3
ri1296 n1072__vddio n1073__vddio 82.51e-3
ri1297 n1073__vddio n1074__vddio 82.51e-3
ri1298 n1074__vddio n1075__vddio 82.51e-3
ri1299 n1075__vddio n1076__vddio 82.51e-3
ri1300 n1076__vddio n1077__vddio 82.51e-3
ri1301 n1077__vddio n14__vddio 165.8e-3
ri1302 n15__i1__net7 n12__i1__net7 128.4e-3
ri1303 n38__clk n35__clk 2.911
ri1304 n35__clk n28__clk 2.406
ri1305 n28__clk n40__clk 1.5969
ri1306 n40__clk n19__clk 779.7e-3
ri1307 n19__clk clk_out 77.53e-3
ri1308 n40__clk n20__clk 180.5e-3
ri1309 n19__clk n21__clk 1.4012
ri1310 n23__i1__net1 n20__i1__net1 2.9085
ri1311 n20__i1__net1 n25__i1__net1 2.4085
ri1312 n25__i1__net1 n8__i1__net1 1.8652
ri1313 n11__i1__net1 n25__i1__net1 500e-3
ri1314 n777__i0__i14__net1 n774__i0__i14__net1 130.2e-3
ri1316 n774__i0__i14__net1 n771__i0__i14__net1 18.86e-3
ri1318 n771__i0__i14__net1 n765__i0__i14__net1 22.45e-3
ri1320 n765__i0__i14__net1 n761__i0__i14__net1 18.86e-3
ri1322 n761__i0__i14__net1 n759__i0__i14__net1 22.45e-3
ri1324 n759__i0__i14__net1 n755__i0__i14__net1 18.86e-3
ri1326 n755__i0__i14__net1 n749__i0__i14__net1 22.45e-3
ri1328 n749__i0__i14__net1 n747__i0__i14__net1 18.86e-3
ri1330 n747__i0__i14__net1 n741__i0__i14__net1 21.86e-3
ri1332 n741__i0__i14__net1 n739__i0__i14__net1 18.86e-3
ri1334 n739__i0__i14__net1 n737__i0__i14__net1 22.45e-3
ri1336 n737__i0__i14__net1 n731__i0__i14__net1 18.86e-3
ri1338 n731__i0__i14__net1 n729__i0__i14__net1 22.45e-3
ri1340 n729__i0__i14__net1 n723__i0__i14__net1 18.86e-3
ri1342 n723__i0__i14__net1 n719__i0__i14__net1 22.45e-3
ri1344 n719__i0__i14__net1 n711__i0__i14__net1 18.86e-3
ri1346 n711__i0__i14__net1 n699__i0__i14__net1 22.45e-3
ri1348 n699__i0__i14__net1 n695__i0__i14__net1 18.86e-3
ri1350 n695__i0__i14__net1 n683__i0__i14__net1 22.45e-3
ri1352 n683__i0__i14__net1 n679__i0__i14__net1 18.86e-3
ri1354 n679__i0__i14__net1 n666__i0__i14__net1 22.45e-3
ri1356 n666__i0__i14__net1 n663__i0__i14__net1 18.86e-3
ri1358 n663__i0__i14__net1 n649__i0__i14__net1 22.45e-3
ri1360 n649__i0__i14__net1 n643__i0__i14__net1 18.86e-3
ri1362 n643__i0__i14__net1 n639__i0__i14__net1 21.86e-3
ri1364 n639__i0__i14__net1 n631__i0__i14__net1 18.86e-3
ri1366 n631__i0__i14__net1 n622__i0__i14__net1 22.45e-3
ri1368 n622__i0__i14__net1 n615__i0__i14__net1 18.86e-3
ri1370 n615__i0__i14__net1 n607__i0__i14__net1 22.45e-3
ri1372 n607__i0__i14__net1 n599__i0__i14__net1 18.86e-3
ri1374 n599__i0__i14__net1 n587__i0__i14__net1 22.45e-3
ri1376 n587__i0__i14__net1 n583__i0__i14__net1 18.86e-3
ri1378 n583__i0__i14__net1 n571__i0__i14__net1 22.45e-3
ri1380 n571__i0__i14__net1 n565__i0__i14__net1 18.86e-3
ri1382 n565__i0__i14__net1 n554__i0__i14__net1 22.45e-3
ri1384 n554__i0__i14__net1 n551__i0__i14__net1 18.86e-3
ri1386 n551__i0__i14__net1 n538__i0__i14__net1 21.86e-3
ri1388 n538__i0__i14__net1 n535__i0__i14__net1 18.86e-3
ri1390 n535__i0__i14__net1 n527__i0__i14__net1 22.45e-3
ri1392 n527__i0__i14__net1 n519__i0__i14__net1 18.86e-3
ri1394 n519__i0__i14__net1 n511__i0__i14__net1 22.45e-3
ri1396 n511__i0__i14__net1 n503__i0__i14__net1 18.86e-3
ri1398 n503__i0__i14__net1 n494__i0__i14__net1 22.45e-3
ri1400 n494__i0__i14__net1 n485__i0__i14__net1 18.86e-3
ri1402 n485__i0__i14__net1 n475__i0__i14__net1 22.45e-3
ri1404 n475__i0__i14__net1 n471__i0__i14__net1 18.86e-3
ri1406 n471__i0__i14__net1 n458__i0__i14__net1 22.45e-3
ri1408 n458__i0__i14__net1 n455__i0__i14__net1 18.86e-3
ri1410 n455__i0__i14__net1 n443__i0__i14__net1 22.45e-3
ri1412 n443__i0__i14__net1 n439__i0__i14__net1 18.86e-3
ri1414 n439__i0__i14__net1 n427__i0__i14__net1 22.45e-3
ri1416 n427__i0__i14__net1 n417__i0__i14__net1 18.86e-3
ri1418 n417__i0__i14__net1 n415__i0__i14__net1 23.05e-3
ri1420 n415__i0__i14__net1 n401__i0__i14__net1 18.86e-3
ri1422 n401__i0__i14__net1 n399__i0__i14__net1 22.45e-3
ri1424 n399__i0__i14__net1 n385__i0__i14__net1 18.86e-3
ri1426 n385__i0__i14__net1 n383__i0__i14__net1 23.05e-3
ri1428 n383__i0__i14__net1 n369__i0__i14__net1 18.86e-3
ri1430 n369__i0__i14__net1 n367__i0__i14__net1 22.45e-3
ri1432 n367__i0__i14__net1 n353__i0__i14__net1 18.86e-3
ri1434 n353__i0__i14__net1 n351__i0__i14__net1 22.45e-3
ri1436 n351__i0__i14__net1 n337__i0__i14__net1 18.86e-3
ri1438 n337__i0__i14__net1 n335__i0__i14__net1 22.45e-3
ri1440 n335__i0__i14__net1 n321__i0__i14__net1 18.86e-3
ri1442 n321__i0__i14__net1 n319__i0__i14__net1 21.86e-3
ri1444 n319__i0__i14__net1 n305__i0__i14__net1 18.86e-3
ri1446 n305__i0__i14__net1 n303__i0__i14__net1 22.45e-3
ri1448 n303__i0__i14__net1 n289__i0__i14__net1 18.86e-3
ri1450 n289__i0__i14__net1 n283__i0__i14__net1 22.45e-3
ri1452 n283__i0__i14__net1 n273__i0__i14__net1 18.86e-3
ri1454 n273__i0__i14__net1 n267__i0__i14__net1 22.45e-3
ri1456 n267__i0__i14__net1 n263__i0__i14__net1 18.86e-3
ri1458 n263__i0__i14__net1 n251__i0__i14__net1 22.45e-3
ri1460 n251__i0__i14__net1 n247__i0__i14__net1 18.86e-3
ri1462 n247__i0__i14__net1 n235__i0__i14__net1 22.45e-3
ri1464 n235__i0__i14__net1 n231__i0__i14__net1 18.86e-3
ri1466 n231__i0__i14__net1 n219__i0__i14__net1 22.45e-3
ri1468 n219__i0__i14__net1 n215__i0__i14__net1 18.86e-3
ri1470 n215__i0__i14__net1 n203__i0__i14__net1 22.45e-3
ri1472 n203__i0__i14__net1 n193__i0__i14__net1 18.86e-3
ri1474 n193__i0__i14__net1 n187__i0__i14__net1 21.86e-3
ri1476 n187__i0__i14__net1 n183__i0__i14__net1 18.86e-3
ri1478 n183__i0__i14__net1 n171__i0__i14__net1 22.45e-3
ri1480 n171__i0__i14__net1 n167__i0__i14__net1 18.86e-3
ri1482 n167__i0__i14__net1 n155__i0__i14__net1 22.45e-3
ri1484 n155__i0__i14__net1 n151__i0__i14__net1 18.86e-3
ri1486 n151__i0__i14__net1 n139__i0__i14__net1 22.45e-3
ri1488 n139__i0__i14__net1 n135__i0__i14__net1 18.86e-3
ri1490 n135__i0__i14__net1 n123__i0__i14__net1 22.45e-3
ri1492 n123__i0__i14__net1 n119__i0__i14__net1 18.86e-3
ri1494 n119__i0__i14__net1 n107__i0__i14__net1 22.45e-3
ri1496 n107__i0__i14__net1 n103__i0__i14__net1 18.86e-3
ri1498 n103__i0__i14__net1 n91__i0__i14__net1 21.86e-3
ri1500 n91__i0__i14__net1 n87__i0__i14__net1 18.86e-3
ri1502 n87__i0__i14__net1 n75__i0__i14__net1 22.45e-3
ri1504 n75__i0__i14__net1 n69__i0__i14__net1 18.86e-3
ri1506 n69__i0__i14__net1 n63__i0__i14__net1 25.1e-3
ri1508 n14__reset n15__reset 500e-3
ri1509 n19__pinin n20__pinin 500e-3
ri1510 n22__pinin n23__pinin 125e-3
ri1511 n7__pinout n8__pinout 125e-3
ri1512 n1312__i0__i14__net1 n1273__i0__i14__net1 82.15e-3
ri1513 n1273__i0__i14__net1 n1234__i0__i14__net1 82.15e-3
ri1514 n1234__i0__i14__net1 n1195__i0__i14__net1 82.15e-3
ri1515 n1195__i0__i14__net1 n1156__i0__i14__net1 82.15e-3
ri1516 n1156__i0__i14__net1 n1117__i0__i14__net1 82.15e-3
ri1517 n1117__i0__i14__net1 n1078__i0__i14__net1 82.15e-3
ri1518 n1078__i0__i14__net1 n1039__i0__i14__net1 82.15e-3
ri1519 n1039__i0__i14__net1 n1000__i0__i14__net1 79.8e-3
ri1520 n1000__i0__i14__net1 n961__i0__i14__net1 82.15e-3
ri1521 n961__i0__i14__net1 n922__i0__i14__net1 82.15e-3
ri1522 n922__i0__i14__net1 n883__i0__i14__net1 82.15e-3
ri1523 n883__i0__i14__net1 n844__i0__i14__net1 82.15e-3
ri1524 n844__i0__i14__net1 n805__i0__i14__net1 82.15e-3
ri1525 n805__i0__i14__net1 n1324__i0__i14__net1 172.8e-3
ri1526 n1314__i0__i14__net1 n1275__i0__i14__net1 82.15e-3
ri1527 n1275__i0__i14__net1 n1236__i0__i14__net1 82.15e-3
ri1528 n1236__i0__i14__net1 n1197__i0__i14__net1 82.15e-3
ri1529 n1197__i0__i14__net1 n1158__i0__i14__net1 82.15e-3
ri1530 n1158__i0__i14__net1 n1119__i0__i14__net1 82.15e-3
ri1531 n1119__i0__i14__net1 n1080__i0__i14__net1 82.15e-3
ri1532 n1080__i0__i14__net1 n1041__i0__i14__net1 82.15e-3
ri1533 n1041__i0__i14__net1 n1002__i0__i14__net1 79.8e-3
ri1534 n1002__i0__i14__net1 n963__i0__i14__net1 82.15e-3
ri1535 n963__i0__i14__net1 n924__i0__i14__net1 82.15e-3
ri1536 n924__i0__i14__net1 n885__i0__i14__net1 82.15e-3
ri1537 n885__i0__i14__net1 n846__i0__i14__net1 82.15e-3
ri1538 n846__i0__i14__net1 n807__i0__i14__net1 82.15e-3
ri1539 n807__i0__i14__net1 n1325__i0__i14__net1 172.8e-3
ri1540 n1311__i0__i14__net1 n1272__i0__i14__net1 82.51e-3
ri1541 n1272__i0__i14__net1 n1233__i0__i14__net1 82.51e-3
ri1542 n1233__i0__i14__net1 n1194__i0__i14__net1 82.51e-3
ri1543 n1194__i0__i14__net1 n1155__i0__i14__net1 82.51e-3
ri1544 n1155__i0__i14__net1 n1116__i0__i14__net1 82.51e-3
ri1545 n1116__i0__i14__net1 n1077__i0__i14__net1 82.51e-3
ri1546 n1077__i0__i14__net1 n1038__i0__i14__net1 82.51e-3
ri1547 n1038__i0__i14__net1 n999__i0__i14__net1 80.16e-3
ri1548 n999__i0__i14__net1 n960__i0__i14__net1 82.51e-3
ri1549 n960__i0__i14__net1 n921__i0__i14__net1 82.51e-3
ri1550 n921__i0__i14__net1 n882__i0__i14__net1 82.51e-3
ri1551 n882__i0__i14__net1 n843__i0__i14__net1 82.51e-3
ri1552 n843__i0__i14__net1 n804__i0__i14__net1 82.51e-3
ri1553 n804__i0__i14__net1 n1326__i0__i14__net1 173.6e-3
ri1554 n1313__i0__i14__net1 n1274__i0__i14__net1 82.51e-3
ri1555 n1274__i0__i14__net1 n1235__i0__i14__net1 82.51e-3
ri1556 n1235__i0__i14__net1 n1196__i0__i14__net1 82.51e-3
ri1557 n1196__i0__i14__net1 n1157__i0__i14__net1 82.51e-3
ri1558 n1157__i0__i14__net1 n1118__i0__i14__net1 82.51e-3
ri1559 n1118__i0__i14__net1 n1079__i0__i14__net1 82.51e-3
ri1560 n1079__i0__i14__net1 n1040__i0__i14__net1 82.51e-3
ri1561 n1040__i0__i14__net1 n1001__i0__i14__net1 80.16e-3
ri1562 n1001__i0__i14__net1 n962__i0__i14__net1 82.51e-3
ri1563 n962__i0__i14__net1 n923__i0__i14__net1 82.51e-3
ri1564 n923__i0__i14__net1 n884__i0__i14__net1 82.51e-3
ri1565 n884__i0__i14__net1 n845__i0__i14__net1 82.51e-3
ri1566 n845__i0__i14__net1 n806__i0__i14__net1 82.51e-3
ri1567 n806__i0__i14__net1 n1327__i0__i14__net1 173e-3
ri1568 n1315__i0__i14__net1 n1276__i0__i14__net1 82.51e-3
ri1569 n1276__i0__i14__net1 n1237__i0__i14__net1 82.51e-3
ri1570 n1237__i0__i14__net1 n1198__i0__i14__net1 82.51e-3
ri1571 n1198__i0__i14__net1 n1159__i0__i14__net1 82.51e-3
ri1572 n1159__i0__i14__net1 n1120__i0__i14__net1 82.51e-3
ri1573 n1120__i0__i14__net1 n1081__i0__i14__net1 82.51e-3
ri1574 n1081__i0__i14__net1 n1042__i0__i14__net1 82.51e-3
ri1575 n1042__i0__i14__net1 n1003__i0__i14__net1 80.16e-3
ri1576 n1003__i0__i14__net1 n964__i0__i14__net1 82.51e-3
ri1577 n964__i0__i14__net1 n925__i0__i14__net1 82.51e-3
ri1578 n925__i0__i14__net1 n886__i0__i14__net1 82.51e-3
ri1579 n886__i0__i14__net1 n847__i0__i14__net1 82.51e-3
ri1580 n847__i0__i14__net1 n808__i0__i14__net1 82.51e-3
ri1581 n808__i0__i14__net1 n1328__i0__i14__net1 173e-3
ri1582 n1316__i0__i14__net1 n1277__i0__i14__net1 82.51e-3
ri1583 n1277__i0__i14__net1 n1238__i0__i14__net1 82.51e-3
ri1584 n1238__i0__i14__net1 n1199__i0__i14__net1 82.51e-3
ri1585 n1199__i0__i14__net1 n1160__i0__i14__net1 82.51e-3
ri1586 n1160__i0__i14__net1 n1121__i0__i14__net1 82.51e-3
ri1587 n1121__i0__i14__net1 n1082__i0__i14__net1 82.51e-3
ri1588 n1082__i0__i14__net1 n1043__i0__i14__net1 82.51e-3
ri1589 n1043__i0__i14__net1 n1004__i0__i14__net1 80.16e-3
ri1590 n1004__i0__i14__net1 n965__i0__i14__net1 82.51e-3
ri1591 n965__i0__i14__net1 n926__i0__i14__net1 82.51e-3
ri1592 n926__i0__i14__net1 n887__i0__i14__net1 82.51e-3
ri1593 n887__i0__i14__net1 n848__i0__i14__net1 82.51e-3
ri1594 n848__i0__i14__net1 n809__i0__i14__net1 82.51e-3
ri1595 n809__i0__i14__net1 n1329__i0__i14__net1 173.6e-3
ri1596 n1317__i0__i14__net1 n1278__i0__i14__net1 82.51e-3
ri1597 n1278__i0__i14__net1 n1239__i0__i14__net1 82.51e-3
ri1598 n1239__i0__i14__net1 n1200__i0__i14__net1 82.51e-3
ri1599 n1200__i0__i14__net1 n1161__i0__i14__net1 82.51e-3
ri1600 n1161__i0__i14__net1 n1122__i0__i14__net1 82.51e-3
ri1601 n1122__i0__i14__net1 n1083__i0__i14__net1 82.51e-3
ri1602 n1083__i0__i14__net1 n1044__i0__i14__net1 82.51e-3
ri1603 n1044__i0__i14__net1 n1005__i0__i14__net1 80.16e-3
ri1604 n1005__i0__i14__net1 n966__i0__i14__net1 82.51e-3
ri1605 n966__i0__i14__net1 n927__i0__i14__net1 82.51e-3
ri1606 n927__i0__i14__net1 n888__i0__i14__net1 82.51e-3
ri1607 n888__i0__i14__net1 n849__i0__i14__net1 82.51e-3
ri1608 n849__i0__i14__net1 n810__i0__i14__net1 82.51e-3
ri1609 n810__i0__i14__net1 n1330__i0__i14__net1 173e-3
ri1610 n1318__i0__i14__net1 n1279__i0__i14__net1 82.51e-3
ri1611 n1279__i0__i14__net1 n1240__i0__i14__net1 82.51e-3
ri1612 n1240__i0__i14__net1 n1201__i0__i14__net1 82.51e-3
ri1613 n1201__i0__i14__net1 n1162__i0__i14__net1 82.51e-3
ri1614 n1162__i0__i14__net1 n1123__i0__i14__net1 82.51e-3
ri1615 n1123__i0__i14__net1 n1084__i0__i14__net1 82.51e-3
ri1616 n1084__i0__i14__net1 n1045__i0__i14__net1 82.51e-3
ri1617 n1045__i0__i14__net1 n1006__i0__i14__net1 80.16e-3
ri1618 n1006__i0__i14__net1 n967__i0__i14__net1 82.51e-3
ri1619 n967__i0__i14__net1 n928__i0__i14__net1 82.51e-3
ri1620 n928__i0__i14__net1 n889__i0__i14__net1 82.51e-3
ri1621 n889__i0__i14__net1 n850__i0__i14__net1 82.51e-3
ri1622 n850__i0__i14__net1 n811__i0__i14__net1 82.51e-3
ri1623 n811__i0__i14__net1 n1331__i0__i14__net1 173.6e-3
ri1624 n1319__i0__i14__net1 n1280__i0__i14__net1 82.51e-3
ri1625 n1280__i0__i14__net1 n1241__i0__i14__net1 82.51e-3
ri1626 n1241__i0__i14__net1 n1202__i0__i14__net1 82.51e-3
ri1627 n1202__i0__i14__net1 n1163__i0__i14__net1 82.51e-3
ri1628 n1163__i0__i14__net1 n1124__i0__i14__net1 82.51e-3
ri1629 n1124__i0__i14__net1 n1085__i0__i14__net1 82.51e-3
ri1630 n1085__i0__i14__net1 n1046__i0__i14__net1 82.51e-3
ri1631 n1046__i0__i14__net1 n1007__i0__i14__net1 80.16e-3
ri1632 n1007__i0__i14__net1 n968__i0__i14__net1 82.51e-3
ri1633 n968__i0__i14__net1 n929__i0__i14__net1 82.51e-3
ri1634 n929__i0__i14__net1 n890__i0__i14__net1 82.51e-3
ri1635 n890__i0__i14__net1 n851__i0__i14__net1 82.51e-3
ri1636 n851__i0__i14__net1 n812__i0__i14__net1 82.51e-3
ri1637 n812__i0__i14__net1 n1332__i0__i14__net1 173e-3
ri1638 n1320__i0__i14__net1 n1281__i0__i14__net1 82.51e-3
ri1639 n1281__i0__i14__net1 n1242__i0__i14__net1 82.51e-3
ri1640 n1242__i0__i14__net1 n1203__i0__i14__net1 82.51e-3
ri1641 n1203__i0__i14__net1 n1164__i0__i14__net1 82.51e-3
ri1642 n1164__i0__i14__net1 n1125__i0__i14__net1 82.51e-3
ri1643 n1125__i0__i14__net1 n1086__i0__i14__net1 82.51e-3
ri1644 n1086__i0__i14__net1 n1047__i0__i14__net1 82.51e-3
ri1645 n1047__i0__i14__net1 n1008__i0__i14__net1 80.16e-3
ri1646 n1008__i0__i14__net1 n969__i0__i14__net1 82.51e-3
ri1647 n969__i0__i14__net1 n930__i0__i14__net1 82.51e-3
ri1648 n930__i0__i14__net1 n891__i0__i14__net1 82.51e-3
ri1649 n891__i0__i14__net1 n852__i0__i14__net1 82.51e-3
ri1650 n852__i0__i14__net1 n813__i0__i14__net1 82.51e-3
ri1651 n813__i0__i14__net1 n1333__i0__i14__net1 173e-3
ri1652 n1321__i0__i14__net1 n1282__i0__i14__net1 82.51e-3
ri1653 n1282__i0__i14__net1 n1243__i0__i14__net1 82.51e-3
ri1654 n1243__i0__i14__net1 n1204__i0__i14__net1 82.51e-3
ri1655 n1204__i0__i14__net1 n1165__i0__i14__net1 82.51e-3
ri1656 n1165__i0__i14__net1 n1126__i0__i14__net1 82.51e-3
ri1657 n1126__i0__i14__net1 n1087__i0__i14__net1 82.51e-3
ri1658 n1087__i0__i14__net1 n1048__i0__i14__net1 82.51e-3
ri1659 n1048__i0__i14__net1 n1009__i0__i14__net1 80.16e-3
ri1660 n1009__i0__i14__net1 n970__i0__i14__net1 82.51e-3
ri1661 n970__i0__i14__net1 n931__i0__i14__net1 82.51e-3
ri1662 n931__i0__i14__net1 n892__i0__i14__net1 82.51e-3
ri1663 n892__i0__i14__net1 n853__i0__i14__net1 82.51e-3
ri1664 n853__i0__i14__net1 n814__i0__i14__net1 82.51e-3
ri1665 n814__i0__i14__net1 n1334__i0__i14__net1 173e-3
ri1666 n1322__i0__i14__net1 n1283__i0__i14__net1 82.51e-3
ri1667 n1283__i0__i14__net1 n1244__i0__i14__net1 82.51e-3
ri1668 n1244__i0__i14__net1 n1205__i0__i14__net1 82.51e-3
ri1669 n1205__i0__i14__net1 n1166__i0__i14__net1 82.51e-3
ri1670 n1166__i0__i14__net1 n1127__i0__i14__net1 82.51e-3
ri1671 n1127__i0__i14__net1 n1088__i0__i14__net1 82.51e-3
ri1672 n1088__i0__i14__net1 n1049__i0__i14__net1 82.51e-3
ri1673 n1049__i0__i14__net1 n1010__i0__i14__net1 80.16e-3
ri1674 n1010__i0__i14__net1 n971__i0__i14__net1 82.51e-3
ri1675 n971__i0__i14__net1 n932__i0__i14__net1 82.51e-3
ri1676 n932__i0__i14__net1 n893__i0__i14__net1 82.51e-3
ri1677 n893__i0__i14__net1 n854__i0__i14__net1 82.51e-3
ri1678 n854__i0__i14__net1 n815__i0__i14__net1 82.51e-3
ri1679 n815__i0__i14__net1 n1335__i0__i14__net1 173e-3
ri1680 n1323__i0__i14__net1 n1284__i0__i14__net1 82.51e-3
ri1681 n1284__i0__i14__net1 n1245__i0__i14__net1 82.51e-3
ri1682 n1245__i0__i14__net1 n1206__i0__i14__net1 82.51e-3
ri1683 n1206__i0__i14__net1 n1167__i0__i14__net1 82.51e-3
ri1684 n1167__i0__i14__net1 n1128__i0__i14__net1 82.51e-3
ri1685 n1128__i0__i14__net1 n1089__i0__i14__net1 82.51e-3
ri1686 n1089__i0__i14__net1 n1050__i0__i14__net1 82.51e-3
ri1687 n1050__i0__i14__net1 n1011__i0__i14__net1 80.16e-3
ri1688 n1011__i0__i14__net1 n972__i0__i14__net1 82.51e-3
ri1689 n972__i0__i14__net1 n933__i0__i14__net1 82.51e-3
ri1690 n933__i0__i14__net1 n894__i0__i14__net1 82.51e-3
ri1691 n894__i0__i14__net1 n855__i0__i14__net1 82.51e-3
ri1692 n855__i0__i14__net1 n816__i0__i14__net1 82.51e-3
ri1693 n816__i0__i14__net1 n1336__i0__i14__net1 173e-3
ri1694 n1387__vddio n1366__vddio 82.51e-3
ri1695 n1366__vddio n1345__vddio 82.51e-3
ri1696 n1345__vddio n1324__vddio 82.51e-3
ri1697 n1324__vddio n1303__vddio 82.51e-3
ri1698 n1303__vddio n1282__vddio 82.51e-3
ri1699 n1282__vddio n1261__vddio 82.51e-3
ri1700 n1261__vddio n1227__vddio 82.51e-3
ri1701 n1227__vddio n1219__vddio 80.16e-3
ri1702 n1219__vddio n1198__vddio 82.51e-3
ri1703 n1198__vddio n1177__vddio 82.51e-3
ri1704 n1177__vddio n1156__vddio 82.51e-3
ri1705 n1156__vddio n1135__vddio 82.51e-3
ri1706 n1135__vddio n1114__vddio 82.51e-3
ri1707 n1114__vddio n1093__vddio 82.51e-3
ri1708 n1388__vddio n1367__vddio 82.51e-3
ri1709 n1367__vddio n1346__vddio 82.51e-3
ri1710 n1346__vddio n1325__vddio 82.51e-3
ri1711 n1325__vddio n1304__vddio 82.51e-3
ri1712 n1304__vddio n1283__vddio 82.51e-3
ri1713 n1283__vddio n1262__vddio 82.51e-3
ri1714 n1262__vddio n1228__vddio 82.51e-3
ri1715 n1228__vddio n1220__vddio 80.16e-3
ri1716 n1220__vddio n1199__vddio 82.51e-3
ri1717 n1199__vddio n1178__vddio 82.51e-3
ri1718 n1178__vddio n1157__vddio 82.51e-3
ri1719 n1157__vddio n1136__vddio 82.51e-3
ri1720 n1136__vddio n1115__vddio 82.51e-3
ri1721 n1115__vddio n1094__vddio 82.51e-3
ri1722 n1389__vddio n1368__vddio 82.51e-3
ri1723 n1368__vddio n1347__vddio 82.51e-3
ri1724 n1347__vddio n1326__vddio 82.51e-3
ri1725 n1326__vddio n1305__vddio 82.51e-3
ri1726 n1305__vddio n1284__vddio 82.51e-3
ri1727 n1284__vddio n1263__vddio 82.51e-3
ri1728 n1263__vddio n1231__vddio 82.51e-3
ri1729 n1231__vddio n1221__vddio 80.16e-3
ri1730 n1221__vddio n1200__vddio 82.51e-3
ri1731 n1200__vddio n1179__vddio 82.51e-3
ri1732 n1179__vddio n1158__vddio 82.51e-3
ri1733 n1158__vddio n1137__vddio 82.51e-3
ri1734 n1137__vddio n1116__vddio 82.51e-3
ri1735 n1116__vddio n1095__vddio 82.51e-3
ri1736 n1390__vddio n1369__vddio 82.51e-3
ri1737 n1369__vddio n1348__vddio 82.51e-3
ri1738 n1348__vddio n1327__vddio 82.51e-3
ri1739 n1327__vddio n1306__vddio 82.51e-3
ri1740 n1306__vddio n1285__vddio 82.51e-3
ri1741 n1285__vddio n1264__vddio 82.51e-3
ri1742 n1264__vddio n1232__vddio 82.51e-3
ri1743 n1232__vddio n1222__vddio 80.16e-3
ri1744 n1222__vddio n1201__vddio 82.51e-3
ri1745 n1201__vddio n1180__vddio 82.51e-3
ri1746 n1180__vddio n1159__vddio 82.51e-3
ri1747 n1159__vddio n1138__vddio 82.51e-3
ri1748 n1138__vddio n1117__vddio 82.51e-3
ri1749 n1117__vddio n1096__vddio 82.51e-3
ri1750 n1391__vddio n1370__vddio 82.51e-3
ri1751 n1370__vddio n1349__vddio 82.51e-3
ri1752 n1349__vddio n1328__vddio 82.51e-3
ri1753 n1328__vddio n1307__vddio 82.51e-3
ri1754 n1307__vddio n1286__vddio 82.51e-3
ri1755 n1286__vddio n1265__vddio 82.51e-3
ri1756 n1265__vddio n1235__vddio 82.51e-3
ri1757 n1235__vddio n1223__vddio 80.16e-3
ri1758 n1223__vddio n1202__vddio 82.51e-3
ri1759 n1202__vddio n1181__vddio 82.51e-3
ri1760 n1181__vddio n1160__vddio 82.51e-3
ri1761 n1160__vddio n1139__vddio 82.51e-3
ri1762 n1139__vddio n1118__vddio 82.51e-3
ri1763 n1118__vddio n1097__vddio 82.51e-3
ri1764 n1392__vddio n1371__vddio 82.51e-3
ri1765 n1371__vddio n1350__vddio 82.51e-3
ri1766 n1350__vddio n1329__vddio 82.51e-3
ri1767 n1329__vddio n1308__vddio 82.51e-3
ri1768 n1308__vddio n1287__vddio 82.51e-3
ri1769 n1287__vddio n1266__vddio 82.51e-3
ri1770 n1266__vddio n1236__vddio 82.51e-3
ri1771 n1236__vddio n1224__vddio 80.16e-3
ri1772 n1224__vddio n1203__vddio 82.51e-3
ri1773 n1203__vddio n1182__vddio 82.51e-3
ri1774 n1182__vddio n1161__vddio 82.51e-3
ri1775 n1161__vddio n1140__vddio 82.51e-3
ri1776 n1140__vddio n1119__vddio 82.51e-3
ri1777 n1119__vddio n1098__vddio 82.51e-3
ri1778 n1393__vddio n1372__vddio 82.51e-3
ri1779 n1372__vddio n1351__vddio 82.51e-3
ri1780 n1351__vddio n1330__vddio 82.51e-3
ri1781 n1330__vddio n1309__vddio 82.51e-3
ri1782 n1309__vddio n1288__vddio 82.51e-3
ri1783 n1288__vddio n1267__vddio 82.51e-3
ri1784 n1267__vddio n1239__vddio 82.51e-3
ri1785 n1239__vddio n1225__vddio 80.16e-3
ri1786 n1225__vddio n1204__vddio 82.51e-3
ri1787 n1204__vddio n1183__vddio 82.51e-3
ri1788 n1183__vddio n1162__vddio 82.51e-3
ri1789 n1162__vddio n1141__vddio 82.51e-3
ri1790 n1141__vddio n1120__vddio 82.51e-3
ri1791 n1120__vddio n1099__vddio 82.51e-3
ri1792 n1386__vddio n1533__vddio 165.8e-3
ri1793 n1533__vddio n1439__vddio 82.51e-3
ri1794 n1439__vddio n1440__vddio 82.51e-3
ri1795 n1440__vddio n1501__vddio 82.51e-3
ri1796 n1501__vddio n1534__vddio 82.51e-3
ri1797 n1534__vddio n1503__vddio 82.51e-3
ri1798 n1503__vddio n1504__vddio 82.51e-3
ri1799 n1504__vddio n1505__vddio 80.16e-3
ri1800 n1505__vddio n1535__vddio 82.51e-3
ri1801 n1535__vddio n1507__vddio 82.51e-3
ri1802 n1507__vddio n1508__vddio 82.51e-3
ri1803 n1508__vddio n1536__vddio 82.51e-3
ri1804 n1536__vddio n1537__vddio 82.51e-3
ri1805 n1537__vddio n1511__vddio 82.51e-3
ri1806 n1365__vddio n1533__vddio 83.33e-3
ri1807 n1281__vddio n1534__vddio 83.33e-3
ri1808 n1197__vddio n1535__vddio 83.33e-3
ri1809 n1134__vddio n1536__vddio 83.33e-3
ri1810 n1113__vddio n1537__vddio 83.33e-3
ri1811 n970__vss n1109__vss 165.8e-3
ri1812 n1109__vss n1019__vss 82.51e-3
ri1813 n1019__vss n1020__vss 82.51e-3
ri1814 n1020__vss n1021__vss 82.51e-3
ri1815 n1021__vss n1110__vss 82.51e-3
ri1816 n1110__vss n1025__vss 82.51e-3
ri1817 n1025__vss n1028__vss 82.51e-3
ri1818 n1028__vss n1029__vss 80.16e-3
ri1819 n1029__vss n1111__vss 82.51e-3
ri1820 n1111__vss n1033__vss 82.51e-3
ri1821 n1033__vss n1036__vss 82.51e-3
ri1822 n1036__vss n1112__vss 82.51e-3
ri1823 n1112__vss n1113__vss 82.51e-3
ri1824 n1113__vss n1041__vss 82.51e-3
ri1825 n957__vss n1109__vss 83.33e-3
ri1826 n905__vss n1110__vss 83.33e-3
ri1827 n853__vss n1111__vss 83.33e-3
ri1828 n776__vss n1112__vss 83.33e-3
ri1829 n763__vss n1113__vss 83.33e-3
ri1830 n971__vss n958__vss 82.51e-3
ri1831 n958__vss n945__vss 82.51e-3
ri1832 n945__vss n932__vss 82.51e-3
ri1833 n932__vss n919__vss 82.51e-3
ri1834 n919__vss n906__vss 82.51e-3
ri1835 n906__vss n893__vss 82.51e-3
ri1836 n893__vss n872__vss 82.51e-3
ri1837 n872__vss n867__vss 80.16e-3
ri1838 n867__vss n854__vss 82.51e-3
ri1839 n854__vss n841__vss 82.51e-3
ri1840 n841__vss n828__vss 82.51e-3
ri1841 n828__vss n777__vss 82.51e-3
ri1842 n777__vss n764__vss 82.51e-3
ri1843 n764__vss n751__vss 82.51e-3
ri1844 n972__vss n959__vss 82.51e-3
ri1845 n959__vss n946__vss 82.51e-3
ri1846 n946__vss n933__vss 82.51e-3
ri1847 n933__vss n920__vss 82.51e-3
ri1848 n920__vss n907__vss 82.51e-3
ri1849 n907__vss n894__vss 82.51e-3
ri1850 n894__vss n873__vss 82.51e-3
ri1851 n873__vss n868__vss 80.16e-3
ri1852 n868__vss n855__vss 82.51e-3
ri1853 n855__vss n842__vss 82.51e-3
ri1854 n842__vss n829__vss 82.51e-3
ri1855 n829__vss n778__vss 82.51e-3
ri1856 n778__vss n765__vss 82.51e-3
ri1857 n765__vss n752__vss 82.51e-3
ri1858 n973__vss n960__vss 82.51e-3
ri1859 n960__vss n947__vss 82.51e-3
ri1860 n947__vss n934__vss 82.51e-3
ri1861 n934__vss n921__vss 82.51e-3
ri1862 n921__vss n908__vss 82.51e-3
ri1863 n908__vss n895__vss 82.51e-3
ri1864 n895__vss n876__vss 82.51e-3
ri1865 n876__vss n869__vss 80.16e-3
ri1866 n869__vss n856__vss 82.51e-3
ri1867 n856__vss n843__vss 82.51e-3
ri1868 n843__vss n830__vss 82.51e-3
ri1869 n830__vss n779__vss 82.51e-3
ri1870 n779__vss n766__vss 82.51e-3
ri1871 n766__vss n753__vss 82.51e-3
ri1872 n974__vss n961__vss 82.51e-3
ri1873 n961__vss n948__vss 82.51e-3
ri1874 n948__vss n935__vss 82.51e-3
ri1875 n935__vss n922__vss 82.51e-3
ri1876 n922__vss n909__vss 82.51e-3
ri1877 n909__vss n896__vss 82.51e-3
ri1878 n896__vss n877__vss 82.51e-3
ri1879 n877__vss n870__vss 80.16e-3
ri1880 n870__vss n857__vss 82.51e-3
ri1881 n857__vss n844__vss 82.51e-3
ri1882 n844__vss n831__vss 82.51e-3
ri1883 n831__vss n780__vss 82.51e-3
ri1884 n780__vss n767__vss 82.51e-3
ri1885 n767__vss n754__vss 82.51e-3
ri1886 n225__i0__net2 n226__i0__net2 180.3e-3
ri1887 n226__i0__net2 n227__i0__net2 121.9e-3
ri1888 n227__i0__net2 n222__i0__net2 31.44e-3
ri1890 n222__i0__net2 n219__i0__net2 18.97e-3
ri1892 n219__i0__net2 n215__i0__net2 22.52e-3
ri1894 n215__i0__net2 n211__i0__net2 18.97e-3
ri1896 n211__i0__net2 n207__i0__net2 22.52e-3
ri1898 n207__i0__net2 n203__i0__net2 18.97e-3
ri1900 n203__i0__net2 n198__i0__net2 22.52e-3
ri1902 n198__i0__net2 n195__i0__net2 18.97e-3
ri1904 n195__i0__net2 n191__i0__net2 21.93e-3
ri1906 n191__i0__net2 n187__i0__net2 18.97e-3
ri1908 n187__i0__net2 n183__i0__net2 22.52e-3
ri1910 n183__i0__net2 n175__i0__net2 18.97e-3
ri1912 n175__i0__net2 n171__i0__net2 22.52e-3
ri1914 n171__i0__net2 n169__i0__net2 18.97e-3
ri1916 n169__i0__net2 n162__i0__net2 22.52e-3
ri1918 n162__i0__net2 n159__i0__net2 18.97e-3
ri1920 n159__i0__net2 n147__i0__net2 22.52e-3
ri1922 n147__i0__net2 n143__i0__net2 18.97e-3
ri1924 n143__i0__net2 n131__i0__net2 22.52e-3
ri1926 n131__i0__net2 n127__i0__net2 18.97e-3
ri1928 n127__i0__net2 n115__i0__net2 22.52e-3
ri1930 n115__i0__net2 n111__i0__net2 18.97e-3
ri1932 n111__i0__net2 n99__i0__net2 22.52e-3
ri1934 n99__i0__net2 n90__i0__net2 18.97e-3
ri1936 n90__i0__net2 n83__i0__net2 21.93e-3
ri1938 n83__i0__net2 n79__i0__net2 18.97e-3
ri1940 n79__i0__net2 n67__i0__net2 22.52e-3
ri1942 n67__i0__net2 n63__i0__net2 18.97e-3
ri1944 n227__i0__net2 n228__i0__net2 103.1e-3
ri1945 n228__i0__net2 n229__i0__net2 115.8e-3
ri1946 n229__i0__net2 n230__i0__net2 179.3e-3
ri1947 n169__i0__i13__net1 n170__i0__i13__net1 180.3e-3
ri1948 n170__i0__i13__net1 n171__i0__i13__net1 82.3e-3
ri1949 n171__i0__i13__net1 n172__i0__i13__net1 84.76e-3
ri1950 n172__i0__i13__net1 n173__i0__i13__net1 89.85e-3
ri1951 n173__i0__i13__net1 n174__i0__i13__net1 101.6e-3
ri1952 n174__i0__i13__net1 n175__i0__i13__net1 101.6e-3
ri1953 n175__i0__i13__net1 n176__i0__i13__net1 101.6e-3
ri1954 n176__i0__i13__net1 n177__i0__i13__net1 101.6e-3
ri1955 n177__i0__i13__net1 n178__i0__i13__net1 101.6e-3
ri1956 n178__i0__i13__net1 n179__i0__i13__net1 101.6e-3
ri1957 n179__i0__i13__net1 n180__i0__i13__net1 102.3e-3
ri1958 n180__i0__i13__net1 n181__i0__i13__net1 102.3e-3
ri1959 n181__i0__i13__net1 n182__i0__i13__net1 76.48e-3
ri1960 n182__i0__i13__net1 n60__i0__i13__net1 29.56e-3
ri1962 n171__i0__i13__net1 n183__i0__i13__net1 147.7e-3
ri1963 n183__i0__i13__net1 n184__i0__i13__net1 113.6e-3
ri1964 n184__i0__i13__net1 n185__i0__i13__net1 181.7e-3
ri1965 n172__i0__i13__net1 n168__i0__i13__net1 41.52e-3
ri1966 n172__i0__i13__net1 n167__i0__i13__net1 42.86e-3
ri1967 n173__i0__i13__net1 n160__i0__i13__net1 28.84e-3
ri1969 n173__i0__i13__net1 n159__i0__i13__net1 29.76e-3
ri1971 n174__i0__i13__net1 n154__i0__i13__net1 28.84e-3
ri1973 n174__i0__i13__net1 n153__i0__i13__net1 29.76e-3
ri1975 n175__i0__i13__net1 n144__i0__i13__net1 28.84e-3
ri1977 n175__i0__i13__net1 n143__i0__i13__net1 29.76e-3
ri1979 n176__i0__i13__net1 n136__i0__i13__net1 28.84e-3
ri1981 n176__i0__i13__net1 n135__i0__i13__net1 29.76e-3
ri1983 n177__i0__i13__net1 n128__i0__i13__net1 28.84e-3
ri1985 n177__i0__i13__net1 n127__i0__i13__net1 29.76e-3
ri1987 n178__i0__i13__net1 n116__i0__i13__net1 28.84e-3
ri1989 n178__i0__i13__net1 n115__i0__i13__net1 29.76e-3
ri1991 n179__i0__i13__net1 n108__i0__i13__net1 28.84e-3
ri1993 n179__i0__i13__net1 n105__i0__i13__net1 29.76e-3
ri1995 n180__i0__i13__net1 n92__i0__i13__net1 28.34e-3
ri1997 n180__i0__i13__net1 n91__i0__i13__net1 29.25e-3
ri1999 n181__i0__i13__net1 n76__i0__i13__net1 28.84e-3
ri2001 n181__i0__i13__net1 n75__i0__i13__net1 29.76e-3
ri2003 n182__i0__i13__net1 n59__i0__i13__net1 30.48e-3
ri2005 n1703__vddio vddio 85.09e-3
ri2006 vddio n1704__vddio 373.3e-3
ri2007 n1704__vddio n1705__vddio 25.83e-3
ri2008 n1705__vddio n1706__vddio 9.963e-3
ri2009 n1706__vddio n1707__vddio 15.5e-3
ri2010 n1707__vddio n1708__vddio 26.2e-3
ri2011 n1708__vddio n1709__vddio 26.2e-3
ri2012 n1709__vddio n1710__vddio 25.06e-3
ri2013 n1710__vddio n1711__vddio 10.26e-3
ri2014 n1711__vddio n1712__vddio 15.87e-3
ri2015 n1712__vddio n1713__vddio 25.43e-3
ri2016 n1713__vddio n1714__vddio 26.17e-3
ri2017 n1714__vddio n1715__vddio 25.06e-3
ri2018 n1715__vddio n1716__vddio 10.63e-3
ri2019 n1716__vddio n1717__vddio 15.5e-3
ri2020 n1717__vddio n1718__vddio 40.56e-3
ri2021 n1718__vddio n1719__vddio 26.17e-3
ri2022 n1719__vddio n1720__vddio 13.28e-3
ri2023 n1720__vddio n1721__vddio 11.73e-3
ri2024 n1703__vddio n1722__vddio 103.6e-3
ri2025 n1722__vddio n1723__vddio 138.2e-3
ri2026 n1723__vddio n1724__vddio 138.2e-3
ri2027 n1724__vddio n1725__vddio 138.2e-3
ri2028 n1725__vddio n1726__vddio 138.2e-3
ri2029 n1726__vddio n1727__vddio 138.2e-3
ri2030 n1727__vddio n1728__vddio 138.2e-3
ri2031 n1728__vddio n1729__vddio 138.2e-3
ri2032 n1729__vddio n1730__vddio 138.2e-3
ri2033 n1730__vddio n1731__vddio 138.2e-3
ri2034 n1731__vddio n1732__vddio 138.2e-3
ri2035 n1732__vddio n1733__vddio 138.2e-3
ri2036 n1733__vddio n1734__vddio 138.2e-3
ri2037 n1734__vddio n1735__vddio 138.2e-3
ri2038 n1735__vddio n1736__vddio 138.2e-3
ri2039 n1736__vddio n1499__vddio 142.4e-3
ri2040 n1721__vddio n1636__vddio 151.2e-3
ri2041 n1432__vddio n1703__vddio 8.333e-3
ri2042 n1668__vddio n1704__vddio 125e-3
ri2043 n1666__vddio n1705__vddio 125e-3
ri2044 n1701__vddio n1706__vddio 8.333e-3
ri2045 n1664__vddio n1707__vddio 125e-3
ri2046 n1662__vddio n1708__vddio 125e-3
ri2047 n1566__vddio n1709__vddio 125e-3
ri2048 n1659__vddio n1710__vddio 125e-3
ri2049 n1699__vddio n1711__vddio 8.333e-3
ri2050 n1657__vddio n1712__vddio 125e-3
ri2051 n1655__vddio n1713__vddio 125e-3
ri2052 n1653__vddio n1714__vddio 125e-3
ri2053 n1651__vddio n1715__vddio 125e-3
ri2054 n1697__vddio n1716__vddio 8.333e-3
ri2055 n1649__vddio n1717__vddio 125e-3
ri2056 n1615__vddio n1718__vddio 125e-3
ri2057 n1646__vddio n1719__vddio 125e-3
ri2058 n1695__vddio n1720__vddio 9.804e-3
ri2059 n1644__vddio n1721__vddio 125e-3
ri2060 n1436__vddio n1722__vddio 4.167e-3
ri2061 n1443__vddio n1723__vddio 4.167e-3
ri2062 n1447__vddio n1724__vddio 4.167e-3
ri2063 n1451__vddio n1725__vddio 4.167e-3
ri2064 n1455__vddio n1726__vddio 4.167e-3
ri2065 n1459__vddio n1727__vddio 4.167e-3
ri2066 n1463__vddio n1728__vddio 4.167e-3
ri2067 n1467__vddio n1729__vddio 4.167e-3
ri2068 n1471__vddio n1730__vddio 4.167e-3
ri2069 n1475__vddio n1731__vddio 4.167e-3
ri2070 n1479__vddio n1732__vddio 4.167e-3
ri2071 n1483__vddio n1733__vddio 4.167e-3
ri2072 n1487__vddio n1734__vddio 4.167e-3
ri2073 n1491__vddio n1735__vddio 4.167e-3
ri2074 n1495__vddio n1736__vddio 4.167e-3
ri2075 n1210__vss n1258__vss 161.4e-3
ri2076 n1258__vss n1259__vss 15.37e-3
ri2077 n1259__vss n1260__vss 19.47e-3
ri2078 n1260__vss n1261__vss 36.38e-3
ri2079 n1261__vss n1262__vss 56.37e-3
ri2080 n1262__vss n1263__vss 20.5e-3
ri2081 n1263__vss n1264__vss 15.89e-3
ri2082 n1264__vss n1265__vss 34.85e-3
ri2083 n1265__vss n1266__vss 36.38e-3
ri2084 n1266__vss n1267__vss 35.36e-3
ri2085 n1267__vss n1268__vss 21.01e-3
ri2086 n1268__vss n1269__vss 15.37e-3
ri2087 n1269__vss n1270__vss 34.85e-3
ri2088 n1270__vss n1271__vss 36.38e-3
ri2089 n1271__vss n1272__vss 36.38e-3
ri2090 n1272__vss n1257__vss 20.5e-3
ri2091 n1257__vss n1273__vss 15.89e-3
ri2092 n1273__vss n1231__vss 34.94e-3
ri2093 n1231__vss n1274__vss 279.2e-3
ri2094 n1274__vss n1275__vss 103.6e-3
ri2095 n1275__vss n1276__vss 138.2e-3
ri2096 n1276__vss n1277__vss 138.2e-3
ri2097 n1277__vss n1278__vss 138.2e-3
ri2098 n1278__vss n1279__vss 138.2e-3
ri2099 n1279__vss n1280__vss 89.83e-3
ri2100 n1280__vss n1281__vss 28.47e-3
ri2101 n1281__vss n1282__vss 89.83e-3
ri2102 n1282__vss n1283__vss 28.47e-3
ri2103 n1283__vss n648__vss 89.83e-3
ri2104 n648__vss n1284__vss 28.47e-3
ri2105 n1284__vss n1285__vss 138.2e-3
ri2106 n1285__vss n1286__vss 138.2e-3
ri2107 n1286__vss n1287__vss 138.2e-3
ri2108 n1287__vss n1288__vss 138.2e-3
ri2109 n1288__vss n1289__vss 138.2e-3
ri2110 n1289__vss n1290__vss 138.2e-3
ri2111 n1290__vss n1291__vss 138.2e-3
ri2112 n1291__vss n1106__vss 142.4e-3
ri2113 n1201__vss n1258__vss 125e-3
ri2114 n1250__vss n1259__vss 9.804e-3
ri2115 n1213__vss n1260__vss 125e-3
ri2116 n1191__vss n1261__vss 125e-3
ri2117 n1216__vss n1262__vss 125e-3
ri2118 n1252__vss n1263__vss 8.333e-3
ri2119 n1177__vss n1264__vss 125e-3
ri2120 n1219__vss n1265__vss 125e-3
ri2121 n1165__vss n1266__vss 125e-3
ri2122 n1222__vss n1267__vss 125e-3
ri2123 n1254__vss n1268__vss 8.333e-3
ri2124 n1150__vss n1269__vss 125e-3
ri2125 n1225__vss n1270__vss 125e-3
ri2126 n1139__vss n1271__vss 125e-3
ri2127 n1131__vss n1272__vss 125e-3
ri2128 n1125__vss n1273__vss 125e-3
ri2129 n1012__vss n1274__vss 8.333e-3
ri2130 n1016__vss n1275__vss 4.167e-3
ri2131 n1026__vss n1276__vss 4.167e-3
ri2132 n1034__vss n1277__vss 4.167e-3
ri2133 n1042__vss n1278__vss 4.167e-3
ri2134 n1046__vss n1279__vss 4.167e-3
ri2135 n643__vss n1280__vss 4.167e-3
ri2136 n1051__vss n1281__vss 4.167e-3
ri2137 n645__vss n1282__vss 4.167e-3
ri2138 n1055__vss n1283__vss 4.167e-3
ri2139 n1061__vss n1284__vss 4.167e-3
ri2140 n1066__vss n1285__vss 4.167e-3
ri2141 n1073__vss n1286__vss 4.167e-3
ri2142 n1078__vss n1287__vss 4.167e-3
ri2143 n1084__vss n1288__vss 4.167e-3
ri2144 n1090__vss n1289__vss 4.167e-3
ri2145 n1095__vss n1290__vss 4.167e-3
ri2146 n1101__vss n1291__vss 4.167e-3
ri2148 n27__i0__net3 n56__i0__net3 27.21e-3
ri2149 n56__i0__net3 n28__i0__net3 28.95e-3
ri2151 n56__i0__net3 n35__i0__net3 43.92e-3
ri2153 n35__i0__net3 n37__i0__net3 17.53e-3
ri2155 n37__i0__net3 n43__i0__net3 36.24e-3
ri2157 n43__i0__net3 n47__i0__net3 18.14e-3
ri2159 n47__i0__net3 n57__i0__net3 148.1e-3
ri2160 n63__i0__i12__net1 n64__i0__i12__net1 175.2e-3
ri2161 n64__i0__i12__net1 n65__i0__i12__net1 105.2e-3
ri2162 n65__i0__i12__net1 n43__i0__i12__net1 90.77e-3
ri2163 n43__i0__i12__net1 n44__i0__i12__net1 108.5e-3
ri2164 n44__i0__i12__net1 n36__i0__i12__net1 47.82e-3
ri2165 n36__i0__i12__net1 n35__i0__i12__net1 176.4e-3
ri2166 n35__i0__i12__net1 n66__i0__i12__net1 62.69e-3
ri2167 n66__i0__i12__net1 n32__i0__i12__net1 74.5e-3
ri2168 n64__i0__i12__net1 n52__i0__i12__net1 32.85e-3
ri2170 n64__i0__i12__net1 n51__i0__i12__net1 40.41e-3
ri2172 n65__i0__i12__net1 n46__i0__i12__net1 32.78e-3
ri2174 n65__i0__i12__net1 n45__i0__i12__net1 39.87e-3
ri2176 n35__i0__i12__net1 n43__i0__i12__net1 26.15e-3
ri2177 n66__i0__i12__net1 n31__i0__i12__net1 80.91e-3
ri2178 n28__i0__net4 n26__i0__net4 100.9e-3
ri2180 n26__i0__net4 n24__i0__net4 17.26e-3
ri2182 n16__i0__net4 n26__i0__net4 125e-3
ri2183 n33__pinin n34__pinin 250e-3
ri2184 n19__pinout n18__pinout 250e-3
rj1 n18__chipdriverout n26__chipdriverout 166.7e-3
rj2 n27__chipdriverout n19__chipdriverout 166.7e-3
rj3 n21__chipdriverout n28__chipdriverout 166.7e-3
rj4 n29__chipdriverout n22__chipdriverout 166.7e-3
rj5 n24__chipdriverout n30__chipdriverout 166.7e-3
rj6 n31__chipdriverout n14__chipdriverout 83.33e-3
rj7 n12__chipdriverout n32__chipdriverout 166.7e-3
rj8 n33__chipdriverout n11__chipdriverout 166.7e-3
rj9 n9__chipdriverout n34__chipdriverout 166.7e-3
rj10 n35__chipdriverout n8__chipdriverout 166.7e-3
rj11 n6__chipdriverout n36__chipdriverout 166.7e-3
rj12 n37__chipdriverout n5__chipdriverout 166.7e-3
rj13 n2__chipdriverout n38__chipdriverout 166.7e-3
rj14 n63__i0__i14__net1 n61__i0__i14__net1 125e-3
rj15 n62__i0__i14__net1 n63__i0__i14__net1 125e-3
rj16 n7__vss n10__vss 166.7e-3
rj17 n11__vss n6__vss 166.7e-3
rj18 n4__vss n12__vss 166.7e-3
rj19 n13__vss n3__vss 166.7e-3
rj20 n2__vddio n15__vddio 166.7e-3
rj21 n16__vddio n5__vddio 166.7e-3
rj22 n6__vddio n17__vddio 166.7e-3
rj23 n18__vddio n8__vddio 166.7e-3
rj24 n9__vddio n19__vddio 166.7e-3
rj25 n20__vddio n11__vddio 166.7e-3
rj26 n12__vddio n21__vddio 166.7e-3
rj27 n69__i0__i14__net1 n6__i0__i14__net1 250e-3
rj28 n8__i0__i14__net1 n69__i0__i14__net1 250e-3
rj29 n57__chipdriverout n65__chipdriverout 166.7e-3
rj30 n66__chipdriverout n58__chipdriverout 166.7e-3
rj31 n60__chipdriverout n67__chipdriverout 166.7e-3
rj32 n68__chipdriverout n61__chipdriverout 166.7e-3
rj33 n63__chipdriverout n69__chipdriverout 166.7e-3
rj34 n70__chipdriverout n40__chipdriverout 166.7e-3
rj35 n43__chipdriverout n71__chipdriverout 166.7e-3
rj36 n72__chipdriverout n44__chipdriverout 166.7e-3
rj37 n46__chipdriverout n73__chipdriverout 166.7e-3
rj38 n74__chipdriverout n47__chipdriverout 166.7e-3
rj39 n49__chipdriverout n75__chipdriverout 166.7e-3
rj40 n76__chipdriverout n50__chipdriverout 166.7e-3
rj41 n52__chipdriverout n77__chipdriverout 166.7e-3
rj42 n73__i0__i14__net1 n75__i0__i14__net1 125e-3
rj43 n75__i0__i14__net1 n74__i0__i14__net1 125e-3
rj44 n20__vss n23__vss 166.7e-3
rj45 n24__vss n19__vss 166.7e-3
rj46 n17__vss n25__vss 166.7e-3
rj47 n26__vss n16__vss 166.7e-3
rj48 n23__vddio n36__vddio 166.7e-3
rj49 n37__vddio n26__vddio 166.7e-3
rj50 n27__vddio n38__vddio 166.7e-3
rj51 n39__vddio n29__vddio 166.7e-3
rj52 n30__vddio n40__vddio 166.7e-3
rj53 n41__vddio n32__vddio 166.7e-3
rj54 n33__vddio n42__vddio 166.7e-3
rj55 n87__i0__i14__net1 n85__i0__i14__net1 125e-3
rj56 n86__i0__i14__net1 n87__i0__i14__net1 125e-3
rj57 n96__chipdriverout n104__chipdriverout 166.7e-3
rj58 n105__chipdriverout n97__chipdriverout 166.7e-3
rj59 n99__chipdriverout n106__chipdriverout 166.7e-3
rj60 n107__chipdriverout n100__chipdriverout 166.7e-3
rj61 n102__chipdriverout n108__chipdriverout 166.7e-3
rj62 n109__chipdriverout n79__chipdriverout 166.7e-3
rj63 n82__chipdriverout n110__chipdriverout 166.7e-3
rj64 n111__chipdriverout n83__chipdriverout 166.7e-3
rj65 n85__chipdriverout n112__chipdriverout 166.7e-3
rj66 n113__chipdriverout n86__chipdriverout 166.7e-3
rj67 n88__chipdriverout n114__chipdriverout 166.7e-3
rj68 n115__chipdriverout n89__chipdriverout 166.7e-3
rj69 n91__chipdriverout n116__chipdriverout 166.7e-3
rj70 n89__i0__i14__net1 n91__i0__i14__net1 125e-3
rj71 n91__i0__i14__net1 n90__i0__i14__net1 125e-3
rj72 n33__vss n36__vss 166.7e-3
rj73 n37__vss n32__vss 166.7e-3
rj74 n30__vss n38__vss 166.7e-3
rj75 n39__vss n29__vss 166.7e-3
rj76 n44__vddio n57__vddio 166.7e-3
rj77 n58__vddio n47__vddio 166.7e-3
rj78 n48__vddio n59__vddio 166.7e-3
rj79 n60__vddio n50__vddio 166.7e-3
rj80 n51__vddio n61__vddio 166.7e-3
rj81 n62__vddio n53__vddio 166.7e-3
rj82 n54__vddio n63__vddio 166.7e-3
rj83 n103__i0__i14__net1 n101__i0__i14__net1 125e-3
rj84 n102__i0__i14__net1 n103__i0__i14__net1 125e-3
rj85 n135__chipdriverout n143__chipdriverout 166.7e-3
rj86 n144__chipdriverout n136__chipdriverout 166.7e-3
rj87 n138__chipdriverout n145__chipdriverout 166.7e-3
rj88 n146__chipdriverout n139__chipdriverout 166.7e-3
rj89 n141__chipdriverout n147__chipdriverout 166.7e-3
rj90 n148__chipdriverout n118__chipdriverout 166.7e-3
rj91 n121__chipdriverout n149__chipdriverout 166.7e-3
rj92 n150__chipdriverout n122__chipdriverout 166.7e-3
rj93 n124__chipdriverout n151__chipdriverout 166.7e-3
rj94 n152__chipdriverout n125__chipdriverout 166.7e-3
rj95 n127__chipdriverout n153__chipdriverout 166.7e-3
rj96 n154__chipdriverout n128__chipdriverout 166.7e-3
rj97 n130__chipdriverout n155__chipdriverout 166.7e-3
rj98 n105__i0__i14__net1 n107__i0__i14__net1 125e-3
rj99 n107__i0__i14__net1 n106__i0__i14__net1 125e-3
rj100 n46__vss n49__vss 166.7e-3
rj101 n50__vss n45__vss 166.7e-3
rj102 n43__vss n51__vss 166.7e-3
rj103 n52__vss n42__vss 166.7e-3
rj104 n65__vddio n78__vddio 166.7e-3
rj105 n79__vddio n68__vddio 166.7e-3
rj106 n69__vddio n80__vddio 166.7e-3
rj107 n81__vddio n71__vddio 166.7e-3
rj108 n72__vddio n82__vddio 166.7e-3
rj109 n83__vddio n74__vddio 166.7e-3
rj110 n75__vddio n84__vddio 166.7e-3
rj111 n119__i0__i14__net1 n117__i0__i14__net1 125e-3
rj112 n118__i0__i14__net1 n119__i0__i14__net1 125e-3
rj113 n159__chipdriverout n182__chipdriverout 166.7e-3
rj114 n183__chipdriverout n160__chipdriverout 166.7e-3
rj115 n162__chipdriverout n184__chipdriverout 166.7e-3
rj116 n185__chipdriverout n163__chipdriverout 166.7e-3
rj117 n165__chipdriverout n186__chipdriverout 166.7e-3
rj118 n187__chipdriverout n168__chipdriverout 166.7e-3
rj119 n171__chipdriverout n188__chipdriverout 166.7e-3
rj120 n189__chipdriverout n172__chipdriverout 166.7e-3
rj121 n174__chipdriverout n190__chipdriverout 166.7e-3
rj122 n191__chipdriverout n175__chipdriverout 166.7e-3
rj123 n177__chipdriverout n192__chipdriverout 166.7e-3
rj124 n193__chipdriverout n178__chipdriverout 166.7e-3
rj125 n180__chipdriverout n194__chipdriverout 166.7e-3
rj126 n121__i0__i14__net1 n123__i0__i14__net1 125e-3
rj127 n123__i0__i14__net1 n122__i0__i14__net1 125e-3
rj128 n59__vss n62__vss 166.7e-3
rj129 n63__vss n58__vss 166.7e-3
rj130 n56__vss n64__vss 166.7e-3
rj131 n65__vss n55__vss 166.7e-3
rj132 n86__vddio n99__vddio 166.7e-3
rj133 n100__vddio n89__vddio 166.7e-3
rj134 n90__vddio n101__vddio 166.7e-3
rj135 n102__vddio n92__vddio 166.7e-3
rj136 n93__vddio n103__vddio 166.7e-3
rj137 n104__vddio n95__vddio 166.7e-3
rj138 n96__vddio n105__vddio 166.7e-3
rj139 n135__i0__i14__net1 n133__i0__i14__net1 125e-3
rj140 n134__i0__i14__net1 n135__i0__i14__net1 125e-3
rj141 n198__chipdriverout n221__chipdriverout 166.7e-3
rj142 n222__chipdriverout n199__chipdriverout 166.7e-3
rj143 n201__chipdriverout n223__chipdriverout 166.7e-3
rj144 n224__chipdriverout n202__chipdriverout 166.7e-3
rj145 n204__chipdriverout n225__chipdriverout 166.7e-3
rj146 n226__chipdriverout n207__chipdriverout 166.7e-3
rj147 n210__chipdriverout n227__chipdriverout 166.7e-3
rj148 n228__chipdriverout n211__chipdriverout 166.7e-3
rj149 n213__chipdriverout n229__chipdriverout 166.7e-3
rj150 n230__chipdriverout n214__chipdriverout 166.7e-3
rj151 n216__chipdriverout n231__chipdriverout 166.7e-3
rj152 n232__chipdriverout n217__chipdriverout 166.7e-3
rj153 n219__chipdriverout n233__chipdriverout 166.7e-3
rj154 n137__i0__i14__net1 n139__i0__i14__net1 125e-3
rj155 n139__i0__i14__net1 n138__i0__i14__net1 125e-3
rj156 n72__vss n75__vss 166.7e-3
rj157 n76__vss n71__vss 166.7e-3
rj158 n69__vss n77__vss 166.7e-3
rj159 n78__vss n68__vss 166.7e-3
rj160 n107__vddio n120__vddio 166.7e-3
rj161 n121__vddio n110__vddio 166.7e-3
rj162 n111__vddio n122__vddio 166.7e-3
rj163 n123__vddio n113__vddio 166.7e-3
rj164 n114__vddio n124__vddio 166.7e-3
rj165 n125__vddio n116__vddio 166.7e-3
rj166 n117__vddio n126__vddio 166.7e-3
rj167 n151__i0__i14__net1 n149__i0__i14__net1 125e-3
rj168 n150__i0__i14__net1 n151__i0__i14__net1 125e-3
rj169 n237__chipdriverout n260__chipdriverout 166.7e-3
rj170 n261__chipdriverout n238__chipdriverout 166.7e-3
rj171 n240__chipdriverout n262__chipdriverout 166.7e-3
rj172 n263__chipdriverout n241__chipdriverout 166.7e-3
rj173 n243__chipdriverout n264__chipdriverout 166.7e-3
rj174 n265__chipdriverout n246__chipdriverout 166.7e-3
rj175 n249__chipdriverout n266__chipdriverout 166.7e-3
rj176 n267__chipdriverout n250__chipdriverout 166.7e-3
rj177 n252__chipdriverout n268__chipdriverout 166.7e-3
rj178 n269__chipdriverout n253__chipdriverout 166.7e-3
rj179 n255__chipdriverout n270__chipdriverout 166.7e-3
rj180 n271__chipdriverout n256__chipdriverout 166.7e-3
rj181 n258__chipdriverout n272__chipdriverout 166.7e-3
rj182 n153__i0__i14__net1 n155__i0__i14__net1 125e-3
rj183 n155__i0__i14__net1 n154__i0__i14__net1 125e-3
rj184 n85__vss n88__vss 166.7e-3
rj185 n89__vss n84__vss 166.7e-3
rj186 n82__vss n90__vss 166.7e-3
rj187 n91__vss n81__vss 166.7e-3
rj188 n128__vddio n141__vddio 166.7e-3
rj189 n142__vddio n131__vddio 166.7e-3
rj190 n132__vddio n143__vddio 166.7e-3
rj191 n144__vddio n134__vddio 166.7e-3
rj192 n135__vddio n145__vddio 166.7e-3
rj193 n146__vddio n137__vddio 166.7e-3
rj194 n138__vddio n147__vddio 166.7e-3
rj195 n167__i0__i14__net1 n165__i0__i14__net1 125e-3
rj196 n166__i0__i14__net1 n167__i0__i14__net1 125e-3
rj197 n276__chipdriverout n299__chipdriverout 166.7e-3
rj198 n300__chipdriverout n277__chipdriverout 166.7e-3
rj199 n279__chipdriverout n301__chipdriverout 166.7e-3
rj200 n302__chipdriverout n280__chipdriverout 166.7e-3
rj201 n282__chipdriverout n303__chipdriverout 166.7e-3
rj202 n304__chipdriverout n285__chipdriverout 166.7e-3
rj203 n288__chipdriverout n305__chipdriverout 166.7e-3
rj204 n306__chipdriverout n289__chipdriverout 166.7e-3
rj205 n291__chipdriverout n307__chipdriverout 166.7e-3
rj206 n308__chipdriverout n292__chipdriverout 166.7e-3
rj207 n294__chipdriverout n309__chipdriverout 166.7e-3
rj208 n310__chipdriverout n295__chipdriverout 166.7e-3
rj209 n297__chipdriverout n311__chipdriverout 166.7e-3
rj210 n169__i0__i14__net1 n171__i0__i14__net1 125e-3
rj211 n171__i0__i14__net1 n170__i0__i14__net1 125e-3
rj212 n98__vss n101__vss 166.7e-3
rj213 n102__vss n97__vss 166.7e-3
rj214 n95__vss n103__vss 166.7e-3
rj215 n104__vss n94__vss 166.7e-3
rj216 n149__vddio n162__vddio 166.7e-3
rj217 n163__vddio n152__vddio 166.7e-3
rj218 n153__vddio n164__vddio 166.7e-3
rj219 n165__vddio n155__vddio 166.7e-3
rj220 n156__vddio n166__vddio 166.7e-3
rj221 n167__vddio n158__vddio 166.7e-3
rj222 n159__vddio n168__vddio 166.7e-3
rj223 n183__i0__i14__net1 n181__i0__i14__net1 125e-3
rj224 n182__i0__i14__net1 n183__i0__i14__net1 125e-3
rj225 n315__chipdriverout n338__chipdriverout 166.7e-3
rj226 n339__chipdriverout n316__chipdriverout 166.7e-3
rj227 n318__chipdriverout n340__chipdriverout 166.7e-3
rj228 n341__chipdriverout n319__chipdriverout 166.7e-3
rj229 n321__chipdriverout n342__chipdriverout 166.7e-3
rj230 n343__chipdriverout n324__chipdriverout 166.7e-3
rj231 n327__chipdriverout n344__chipdriverout 166.7e-3
rj232 n345__chipdriverout n328__chipdriverout 166.7e-3
rj233 n330__chipdriverout n346__chipdriverout 166.7e-3
rj234 n347__chipdriverout n331__chipdriverout 166.7e-3
rj235 n333__chipdriverout n348__chipdriverout 166.7e-3
rj236 n349__chipdriverout n334__chipdriverout 166.7e-3
rj237 n336__chipdriverout n350__chipdriverout 166.7e-3
rj238 n185__i0__i14__net1 n187__i0__i14__net1 125e-3
rj239 n187__i0__i14__net1 n186__i0__i14__net1 125e-3
rj240 n111__vss n114__vss 166.7e-3
rj241 n115__vss n110__vss 166.7e-3
rj242 n108__vss n116__vss 166.7e-3
rj243 n117__vss n107__vss 166.7e-3
rj244 n170__vddio n183__vddio 166.7e-3
rj245 n184__vddio n173__vddio 166.7e-3
rj246 n174__vddio n185__vddio 166.7e-3
rj247 n186__vddio n176__vddio 166.7e-3
rj248 n177__vddio n187__vddio 166.7e-3
rj249 n188__vddio n179__vddio 166.7e-3
rj250 n180__vddio n189__vddio 166.7e-3
rj251 n193__i0__i14__net1 n82__i0__i14__net1 250e-3
rj252 n84__i0__i14__net1 n193__i0__i14__net1 250e-3
rj253 n354__chipdriverout n377__chipdriverout 166.7e-3
rj254 n378__chipdriverout n355__chipdriverout 166.7e-3
rj255 n357__chipdriverout n379__chipdriverout 166.7e-3
rj256 n380__chipdriverout n358__chipdriverout 166.7e-3
rj257 n360__chipdriverout n381__chipdriverout 166.7e-3
rj258 n382__chipdriverout n363__chipdriverout 166.7e-3
rj259 n366__chipdriverout n383__chipdriverout 166.7e-3
rj260 n384__chipdriverout n367__chipdriverout 166.7e-3
rj261 n369__chipdriverout n385__chipdriverout 166.7e-3
rj262 n386__chipdriverout n370__chipdriverout 166.7e-3
rj263 n372__chipdriverout n387__chipdriverout 166.7e-3
rj264 n388__chipdriverout n373__chipdriverout 166.7e-3
rj265 n375__chipdriverout n389__chipdriverout 166.7e-3
rj266 n201__i0__i14__net1 n203__i0__i14__net1 125e-3
rj267 n203__i0__i14__net1 n202__i0__i14__net1 125e-3
rj268 n124__vss n127__vss 166.7e-3
rj269 n128__vss n123__vss 166.7e-3
rj270 n121__vss n129__vss 166.7e-3
rj271 n130__vss n120__vss 166.7e-3
rj272 n191__vddio n204__vddio 166.7e-3
rj273 n205__vddio n194__vddio 166.7e-3
rj274 n195__vddio n206__vddio 166.7e-3
rj275 n207__vddio n197__vddio 166.7e-3
rj276 n198__vddio n208__vddio 166.7e-3
rj277 n209__vddio n200__vddio 166.7e-3
rj278 n201__vddio n210__vddio 166.7e-3
rj279 n215__i0__i14__net1 n213__i0__i14__net1 125e-3
rj280 n214__i0__i14__net1 n215__i0__i14__net1 125e-3
rj281 n393__chipdriverout n416__chipdriverout 166.7e-3
rj282 n417__chipdriverout n394__chipdriverout 166.7e-3
rj283 n396__chipdriverout n418__chipdriverout 166.7e-3
rj284 n419__chipdriverout n397__chipdriverout 166.7e-3
rj285 n399__chipdriverout n420__chipdriverout 166.7e-3
rj286 n421__chipdriverout n402__chipdriverout 166.7e-3
rj287 n405__chipdriverout n422__chipdriverout 166.7e-3
rj288 n423__chipdriverout n406__chipdriverout 166.7e-3
rj289 n408__chipdriverout n424__chipdriverout 166.7e-3
rj290 n425__chipdriverout n409__chipdriverout 166.7e-3
rj291 n411__chipdriverout n426__chipdriverout 166.7e-3
rj292 n427__chipdriverout n412__chipdriverout 166.7e-3
rj293 n414__chipdriverout n428__chipdriverout 166.7e-3
rj294 n217__i0__i14__net1 n219__i0__i14__net1 125e-3
rj295 n219__i0__i14__net1 n218__i0__i14__net1 125e-3
rj296 n137__vss n140__vss 166.7e-3
rj297 n141__vss n136__vss 166.7e-3
rj298 n134__vss n142__vss 166.7e-3
rj299 n143__vss n133__vss 166.7e-3
rj300 n212__vddio n225__vddio 166.7e-3
rj301 n226__vddio n215__vddio 166.7e-3
rj302 n216__vddio n227__vddio 166.7e-3
rj303 n228__vddio n218__vddio 166.7e-3
rj304 n219__vddio n229__vddio 166.7e-3
rj305 n230__vddio n221__vddio 166.7e-3
rj306 n222__vddio n231__vddio 166.7e-3
rj307 n231__i0__i14__net1 n229__i0__i14__net1 125e-3
rj308 n230__i0__i14__net1 n231__i0__i14__net1 125e-3
rj309 n432__chipdriverout n455__chipdriverout 166.7e-3
rj310 n456__chipdriverout n433__chipdriverout 166.7e-3
rj311 n435__chipdriverout n457__chipdriverout 166.7e-3
rj312 n458__chipdriverout n436__chipdriverout 166.7e-3
rj313 n438__chipdriverout n459__chipdriverout 166.7e-3
rj314 n460__chipdriverout n441__chipdriverout 166.7e-3
rj315 n444__chipdriverout n461__chipdriverout 166.7e-3
rj316 n462__chipdriverout n445__chipdriverout 166.7e-3
rj317 n447__chipdriverout n463__chipdriverout 166.7e-3
rj318 n464__chipdriverout n448__chipdriverout 166.7e-3
rj319 n450__chipdriverout n465__chipdriverout 166.7e-3
rj320 n466__chipdriverout n451__chipdriverout 166.7e-3
rj321 n453__chipdriverout n467__chipdriverout 166.7e-3
rj322 n233__i0__i14__net1 n235__i0__i14__net1 125e-3
rj323 n235__i0__i14__net1 n234__i0__i14__net1 125e-3
rj324 n150__vss n153__vss 166.7e-3
rj325 n154__vss n149__vss 166.7e-3
rj326 n147__vss n155__vss 166.7e-3
rj327 n156__vss n146__vss 166.7e-3
rj328 n233__vddio n246__vddio 166.7e-3
rj329 n247__vddio n236__vddio 166.7e-3
rj330 n237__vddio n248__vddio 166.7e-3
rj331 n249__vddio n239__vddio 166.7e-3
rj332 n240__vddio n250__vddio 166.7e-3
rj333 n251__vddio n242__vddio 166.7e-3
rj334 n243__vddio n252__vddio 166.7e-3
rj335 n247__i0__i14__net1 n245__i0__i14__net1 125e-3
rj336 n246__i0__i14__net1 n247__i0__i14__net1 125e-3
rj337 n468__chipdriverout n469__chipdriverout 166.7e-3
rj338 n470__chipdriverout n471__chipdriverout 166.7e-3
rj339 n472__chipdriverout n473__chipdriverout 166.7e-3
rj340 n474__chipdriverout n475__chipdriverout 166.7e-3
rj341 n476__chipdriverout n477__chipdriverout 166.7e-3
rj342 n478__chipdriverout n479__chipdriverout 166.7e-3
rj343 n480__chipdriverout n481__chipdriverout 166.7e-3
rj344 n482__chipdriverout n483__chipdriverout 166.7e-3
rj345 n484__chipdriverout n485__chipdriverout 166.7e-3
rj346 n486__chipdriverout n487__chipdriverout 166.7e-3
rj347 n488__chipdriverout n489__chipdriverout 166.7e-3
rj348 n490__chipdriverout n491__chipdriverout 166.7e-3
rj349 n492__chipdriverout n493__chipdriverout 166.7e-3
rj350 n249__i0__i14__net1 n251__i0__i14__net1 125e-3
rj351 n251__i0__i14__net1 n250__i0__i14__net1 125e-3
rj352 n166__vss n163__vss 166.7e-3
rj353 n162__vss n167__vss 166.7e-3
rj354 n168__vss n160__vss 166.7e-3
rj355 n159__vss n169__vss 166.7e-3
rj356 n267__vddio n254__vddio 166.7e-3
rj357 n257__vddio n268__vddio 166.7e-3
rj358 n269__vddio n258__vddio 166.7e-3
rj359 n260__vddio n270__vddio 166.7e-3
rj360 n271__vddio n261__vddio 166.7e-3
rj361 n263__vddio n272__vddio 166.7e-3
rj362 n273__vddio n264__vddio 166.7e-3
rj363 n263__i0__i14__net1 n261__i0__i14__net1 125e-3
rj364 n262__i0__i14__net1 n263__i0__i14__net1 125e-3
rj365 n507__chipdriverout n508__chipdriverout 166.7e-3
rj366 n509__chipdriverout n510__chipdriverout 166.7e-3
rj367 n511__chipdriverout n512__chipdriverout 166.7e-3
rj368 n513__chipdriverout n514__chipdriverout 166.7e-3
rj369 n515__chipdriverout n516__chipdriverout 166.7e-3
rj370 n517__chipdriverout n518__chipdriverout 166.7e-3
rj371 n519__chipdriverout n520__chipdriverout 166.7e-3
rj372 n521__chipdriverout n522__chipdriverout 166.7e-3
rj373 n523__chipdriverout n524__chipdriverout 166.7e-3
rj374 n525__chipdriverout n526__chipdriverout 166.7e-3
rj375 n527__chipdriverout n528__chipdriverout 166.7e-3
rj376 n529__chipdriverout n530__chipdriverout 166.7e-3
rj377 n531__chipdriverout n532__chipdriverout 166.7e-3
rj378 n265__i0__i14__net1 n267__i0__i14__net1 125e-3
rj379 n267__i0__i14__net1 n266__i0__i14__net1 125e-3
rj380 n179__vss n176__vss 166.7e-3
rj381 n175__vss n180__vss 166.7e-3
rj382 n181__vss n173__vss 166.7e-3
rj383 n172__vss n182__vss 166.7e-3
rj384 n288__vddio n275__vddio 166.7e-3
rj385 n278__vddio n289__vddio 166.7e-3
rj386 n290__vddio n279__vddio 166.7e-3
rj387 n281__vddio n291__vddio 166.7e-3
rj388 n292__vddio n282__vddio 166.7e-3
rj389 n284__vddio n293__vddio 166.7e-3
rj390 n294__vddio n285__vddio 166.7e-3
rj391 n273__i0__i14__net1 n162__i0__i14__net1 250e-3
rj392 n164__i0__i14__net1 n273__i0__i14__net1 250e-3
rj393 n546__chipdriverout n547__chipdriverout 166.7e-3
rj394 n548__chipdriverout n549__chipdriverout 166.7e-3
rj395 n550__chipdriverout n551__chipdriverout 166.7e-3
rj396 n552__chipdriverout n553__chipdriverout 166.7e-3
rj397 n554__chipdriverout n555__chipdriverout 166.7e-3
rj398 n556__chipdriverout n557__chipdriverout 166.7e-3
rj399 n558__chipdriverout n559__chipdriverout 166.7e-3
rj400 n560__chipdriverout n561__chipdriverout 166.7e-3
rj401 n562__chipdriverout n563__chipdriverout 166.7e-3
rj402 n564__chipdriverout n565__chipdriverout 166.7e-3
rj403 n566__chipdriverout n567__chipdriverout 166.7e-3
rj404 n568__chipdriverout n569__chipdriverout 166.7e-3
rj405 n570__chipdriverout n571__chipdriverout 166.7e-3
rj406 n281__i0__i14__net1 n283__i0__i14__net1 125e-3
rj407 n283__i0__i14__net1 n282__i0__i14__net1 125e-3
rj408 n192__vss n189__vss 166.7e-3
rj409 n188__vss n193__vss 166.7e-3
rj410 n194__vss n186__vss 166.7e-3
rj411 n185__vss n195__vss 166.7e-3
rj412 n309__vddio n296__vddio 166.7e-3
rj413 n299__vddio n310__vddio 166.7e-3
rj414 n311__vddio n300__vddio 166.7e-3
rj415 n302__vddio n312__vddio 166.7e-3
rj416 n313__vddio n303__vddio 166.7e-3
rj417 n305__vddio n314__vddio 166.7e-3
rj418 n315__vddio n306__vddio 166.7e-3
rj419 n289__i0__i14__net1 n178__i0__i14__net1 250e-3
rj420 n180__i0__i14__net1 n289__i0__i14__net1 250e-3
rj421 n585__chipdriverout n586__chipdriverout 166.7e-3
rj422 n587__chipdriverout n588__chipdriverout 166.7e-3
rj423 n589__chipdriverout n590__chipdriverout 166.7e-3
rj424 n591__chipdriverout n592__chipdriverout 166.7e-3
rj425 n593__chipdriverout n594__chipdriverout 166.7e-3
rj426 n595__chipdriverout n596__chipdriverout 166.7e-3
rj427 n597__chipdriverout n598__chipdriverout 166.7e-3
rj428 n599__chipdriverout n600__chipdriverout 166.7e-3
rj429 n601__chipdriverout n602__chipdriverout 166.7e-3
rj430 n603__chipdriverout n604__chipdriverout 166.7e-3
rj431 n605__chipdriverout n606__chipdriverout 166.7e-3
rj432 n607__chipdriverout n608__chipdriverout 166.7e-3
rj433 n609__chipdriverout n610__chipdriverout 166.7e-3
rj434 n301__i0__i14__net1 n303__i0__i14__net1 125e-3
rj435 n303__i0__i14__net1 n302__i0__i14__net1 125e-3
rj436 n205__vss n202__vss 166.7e-3
rj437 n201__vss n206__vss 166.7e-3
rj438 n207__vss n199__vss 166.7e-3
rj439 n198__vss n208__vss 166.7e-3
rj440 n330__vddio n317__vddio 166.7e-3
rj441 n320__vddio n331__vddio 166.7e-3
rj442 n332__vddio n321__vddio 166.7e-3
rj443 n323__vddio n333__vddio 166.7e-3
rj444 n334__vddio n324__vddio 166.7e-3
rj445 n326__vddio n335__vddio 166.7e-3
rj446 n336__vddio n327__vddio 166.7e-3
rj447 n305__i0__i14__net1 n198__i0__i14__net1 250e-3
rj448 n200__i0__i14__net1 n305__i0__i14__net1 250e-3
rj449 n624__chipdriverout n625__chipdriverout 166.7e-3
rj450 n626__chipdriverout n627__chipdriverout 166.7e-3
rj451 n628__chipdriverout n629__chipdriverout 166.7e-3
rj452 n630__chipdriverout n631__chipdriverout 166.7e-3
rj453 n632__chipdriverout n633__chipdriverout 166.7e-3
rj454 n634__chipdriverout n635__chipdriverout 166.7e-3
rj455 n636__chipdriverout n637__chipdriverout 166.7e-3
rj456 n638__chipdriverout n639__chipdriverout 166.7e-3
rj457 n640__chipdriverout n641__chipdriverout 166.7e-3
rj458 n642__chipdriverout n643__chipdriverout 166.7e-3
rj459 n644__chipdriverout n645__chipdriverout 166.7e-3
rj460 n646__chipdriverout n647__chipdriverout 166.7e-3
rj461 n648__chipdriverout n649__chipdriverout 166.7e-3
rj462 n317__i0__i14__net1 n319__i0__i14__net1 125e-3
rj463 n319__i0__i14__net1 n318__i0__i14__net1 125e-3
rj464 n218__vss n215__vss 166.7e-3
rj465 n214__vss n219__vss 166.7e-3
rj466 n220__vss n212__vss 166.7e-3
rj467 n211__vss n221__vss 166.7e-3
rj468 n351__vddio n338__vddio 166.7e-3
rj469 n341__vddio n352__vddio 166.7e-3
rj470 n353__vddio n342__vddio 166.7e-3
rj471 n344__vddio n354__vddio 166.7e-3
rj472 n355__vddio n345__vddio 166.7e-3
rj473 n347__vddio n356__vddio 166.7e-3
rj474 n357__vddio n348__vddio 166.7e-3
rj475 n321__i0__i14__net1 n210__i0__i14__net1 250e-3
rj476 n212__i0__i14__net1 n321__i0__i14__net1 250e-3
rj477 n663__chipdriverout n664__chipdriverout 166.7e-3
rj478 n665__chipdriverout n666__chipdriverout 166.7e-3
rj479 n667__chipdriverout n668__chipdriverout 166.7e-3
rj480 n669__chipdriverout n670__chipdriverout 166.7e-3
rj481 n671__chipdriverout n672__chipdriverout 166.7e-3
rj482 n673__chipdriverout n674__chipdriverout 166.7e-3
rj483 n675__chipdriverout n676__chipdriverout 166.7e-3
rj484 n677__chipdriverout n678__chipdriverout 166.7e-3
rj485 n679__chipdriverout n680__chipdriverout 166.7e-3
rj486 n681__chipdriverout n682__chipdriverout 166.7e-3
rj487 n683__chipdriverout n684__chipdriverout 166.7e-3
rj488 n685__chipdriverout n686__chipdriverout 166.7e-3
rj489 n687__chipdriverout n688__chipdriverout 166.7e-3
rj490 n333__i0__i14__net1 n335__i0__i14__net1 125e-3
rj491 n335__i0__i14__net1 n334__i0__i14__net1 125e-3
rj492 n231__vss n228__vss 166.7e-3
rj493 n227__vss n232__vss 166.7e-3
rj494 n233__vss n225__vss 166.7e-3
rj495 n224__vss n234__vss 166.7e-3
rj496 n372__vddio n359__vddio 166.7e-3
rj497 n362__vddio n373__vddio 166.7e-3
rj498 n374__vddio n363__vddio 166.7e-3
rj499 n365__vddio n375__vddio 166.7e-3
rj500 n376__vddio n366__vddio 166.7e-3
rj501 n368__vddio n377__vddio 166.7e-3
rj502 n378__vddio n369__vddio 166.7e-3
rj503 n337__i0__i14__net1 n226__i0__i14__net1 250e-3
rj504 n228__i0__i14__net1 n337__i0__i14__net1 250e-3
rj505 n702__chipdriverout n703__chipdriverout 166.7e-3
rj506 n704__chipdriverout n705__chipdriverout 166.7e-3
rj507 n706__chipdriverout n707__chipdriverout 166.7e-3
rj508 n708__chipdriverout n709__chipdriverout 166.7e-3
rj509 n710__chipdriverout n711__chipdriverout 166.7e-3
rj510 n712__chipdriverout n713__chipdriverout 166.7e-3
rj511 n714__chipdriverout n715__chipdriverout 166.7e-3
rj512 n716__chipdriverout n717__chipdriverout 166.7e-3
rj513 n718__chipdriverout n719__chipdriverout 166.7e-3
rj514 n720__chipdriverout n721__chipdriverout 166.7e-3
rj515 n722__chipdriverout n723__chipdriverout 166.7e-3
rj516 n724__chipdriverout n725__chipdriverout 166.7e-3
rj517 n726__chipdriverout n727__chipdriverout 166.7e-3
rj518 n349__i0__i14__net1 n351__i0__i14__net1 125e-3
rj519 n351__i0__i14__net1 n350__i0__i14__net1 125e-3
rj520 n241__vss n244__vss 166.7e-3
rj521 n245__vss n240__vss 166.7e-3
rj522 n238__vss n246__vss 166.7e-3
rj523 n247__vss n237__vss 166.7e-3
rj524 n380__vddio n393__vddio 166.7e-3
rj525 n394__vddio n383__vddio 166.7e-3
rj526 n384__vddio n395__vddio 166.7e-3
rj527 n396__vddio n386__vddio 166.7e-3
rj528 n387__vddio n397__vddio 166.7e-3
rj529 n398__vddio n389__vddio 166.7e-3
rj530 n390__vddio n399__vddio 166.7e-3
rj531 n353__i0__i14__net1 n242__i0__i14__net1 250e-3
rj532 n244__i0__i14__net1 n353__i0__i14__net1 250e-3
rj533 n759__chipdriverout n767__chipdriverout 166.7e-3
rj534 n768__chipdriverout n760__chipdriverout 166.7e-3
rj535 n762__chipdriverout n769__chipdriverout 166.7e-3
rj536 n770__chipdriverout n763__chipdriverout 166.7e-3
rj537 n765__chipdriverout n771__chipdriverout 166.7e-3
rj538 n772__chipdriverout n742__chipdriverout 166.7e-3
rj539 n745__chipdriverout n773__chipdriverout 166.7e-3
rj540 n774__chipdriverout n746__chipdriverout 166.7e-3
rj541 n748__chipdriverout n775__chipdriverout 166.7e-3
rj542 n776__chipdriverout n749__chipdriverout 166.7e-3
rj543 n751__chipdriverout n777__chipdriverout 166.7e-3
rj544 n778__chipdriverout n752__chipdriverout 166.7e-3
rj545 n754__chipdriverout n779__chipdriverout 166.7e-3
rj546 n365__i0__i14__net1 n367__i0__i14__net1 125e-3
rj547 n367__i0__i14__net1 n366__i0__i14__net1 125e-3
rj548 n248__vss n249__vss 166.7e-3
rj549 n250__vss n251__vss 166.7e-3
rj550 n252__vss n253__vss 166.7e-3
rj551 n254__vss n255__vss 166.7e-3
rj552 n401__vddio n414__vddio 166.7e-3
rj553 n415__vddio n404__vddio 166.7e-3
rj554 n405__vddio n416__vddio 166.7e-3
rj555 n417__vddio n407__vddio 166.7e-3
rj556 n408__vddio n418__vddio 166.7e-3
rj557 n419__vddio n410__vddio 166.7e-3
rj558 n411__vddio n420__vddio 166.7e-3
rj559 n369__i0__i14__net1 n258__i0__i14__net1 250e-3
rj560 n260__i0__i14__net1 n369__i0__i14__net1 250e-3
rj561 n783__chipdriverout n806__chipdriverout 166.7e-3
rj562 n807__chipdriverout n784__chipdriverout 166.7e-3
rj563 n786__chipdriverout n808__chipdriverout 166.7e-3
rj564 n809__chipdriverout n787__chipdriverout 166.7e-3
rj565 n789__chipdriverout n810__chipdriverout 166.7e-3
rj566 n811__chipdriverout n792__chipdriverout 166.7e-3
rj567 n795__chipdriverout n812__chipdriverout 166.7e-3
rj568 n813__chipdriverout n796__chipdriverout 166.7e-3
rj569 n798__chipdriverout n814__chipdriverout 166.7e-3
rj570 n815__chipdriverout n799__chipdriverout 166.7e-3
rj571 n801__chipdriverout n816__chipdriverout 166.7e-3
rj572 n817__chipdriverout n802__chipdriverout 166.7e-3
rj573 n804__chipdriverout n818__chipdriverout 166.7e-3
rj574 n381__i0__i14__net1 n383__i0__i14__net1 125e-3
rj575 n383__i0__i14__net1 n382__i0__i14__net1 125e-3
rj576 n261__vss n262__vss 166.7e-3
rj577 n263__vss n264__vss 166.7e-3
rj578 n265__vss n266__vss 166.7e-3
rj579 n267__vss n268__vss 166.7e-3
rj580 n422__vddio n435__vddio 166.7e-3
rj581 n436__vddio n425__vddio 166.7e-3
rj582 n426__vddio n437__vddio 166.7e-3
rj583 n438__vddio n428__vddio 166.7e-3
rj584 n429__vddio n439__vddio 166.7e-3
rj585 n440__vddio n431__vddio 166.7e-3
rj586 n432__vddio n441__vddio 166.7e-3
rj587 n385__i0__i14__net1 n278__i0__i14__net1 250e-3
rj588 n280__i0__i14__net1 n385__i0__i14__net1 250e-3
rj589 n822__chipdriverout n845__chipdriverout 166.7e-3
rj590 n846__chipdriverout n823__chipdriverout 166.7e-3
rj591 n825__chipdriverout n847__chipdriverout 166.7e-3
rj592 n848__chipdriverout n826__chipdriverout 166.7e-3
rj593 n828__chipdriverout n849__chipdriverout 166.7e-3
rj594 n850__chipdriverout n831__chipdriverout 166.7e-3
rj595 n834__chipdriverout n851__chipdriverout 166.7e-3
rj596 n852__chipdriverout n835__chipdriverout 166.7e-3
rj597 n837__chipdriverout n853__chipdriverout 166.7e-3
rj598 n854__chipdriverout n838__chipdriverout 166.7e-3
rj599 n840__chipdriverout n855__chipdriverout 166.7e-3
rj600 n856__chipdriverout n841__chipdriverout 166.7e-3
rj601 n843__chipdriverout n857__chipdriverout 166.7e-3
rj602 n397__i0__i14__net1 n399__i0__i14__net1 125e-3
rj603 n399__i0__i14__net1 n398__i0__i14__net1 125e-3
rj604 n274__vss n275__vss 166.7e-3
rj605 n276__vss n277__vss 166.7e-3
rj606 n278__vss n279__vss 166.7e-3
rj607 n280__vss n281__vss 166.7e-3
rj608 n443__vddio n456__vddio 166.7e-3
rj609 n457__vddio n446__vddio 166.7e-3
rj610 n447__vddio n458__vddio 166.7e-3
rj611 n459__vddio n449__vddio 166.7e-3
rj612 n450__vddio n460__vddio 166.7e-3
rj613 n461__vddio n452__vddio 166.7e-3
rj614 n453__vddio n462__vddio 166.7e-3
rj615 n401__i0__i14__net1 n294__i0__i14__net1 250e-3
rj616 n296__i0__i14__net1 n401__i0__i14__net1 250e-3
rj617 n858__chipdriverout n859__chipdriverout 166.7e-3
rj618 n860__chipdriverout n861__chipdriverout 166.7e-3
rj619 n862__chipdriverout n863__chipdriverout 166.7e-3
rj620 n864__chipdriverout n865__chipdriverout 166.7e-3
rj621 n866__chipdriverout n867__chipdriverout 166.7e-3
rj622 n868__chipdriverout n869__chipdriverout 166.7e-3
rj623 n870__chipdriverout n871__chipdriverout 166.7e-3
rj624 n872__chipdriverout n873__chipdriverout 166.7e-3
rj625 n884__chipdriverout n892__chipdriverout 166.7e-3
rj626 n893__chipdriverout n885__chipdriverout 166.7e-3
rj627 n887__chipdriverout n894__chipdriverout 166.7e-3
rj628 n895__chipdriverout n888__chipdriverout 166.7e-3
rj629 n890__chipdriverout n896__chipdriverout 166.7e-3
rj630 n413__i0__i14__net1 n415__i0__i14__net1 125e-3
rj631 n415__i0__i14__net1 n414__i0__i14__net1 125e-3
rj632 n464__vddio n477__vddio 166.7e-3
rj633 n478__vddio n467__vddio 166.7e-3
rj634 n468__vddio n479__vddio 166.7e-3
rj635 n480__vddio n470__vddio 166.7e-3
rj636 n471__vddio n481__vddio 166.7e-3
rj637 n482__vddio n473__vddio 166.7e-3
rj638 n474__vddio n483__vddio 166.7e-3
rj639 n287__vss n288__vss 166.7e-3
rj640 n289__vss n290__vss 166.7e-3
rj641 n291__vss n292__vss 166.7e-3
rj642 n293__vss n294__vss 166.7e-3
rj643 n417__i0__i14__net1 n309__i0__i14__net1 250e-3
rj644 n311__i0__i14__net1 n417__i0__i14__net1 250e-3
rj645 n897__chipdriverout n898__chipdriverout 166.7e-3
rj646 n899__chipdriverout n900__chipdriverout 166.7e-3
rj647 n901__chipdriverout n902__chipdriverout 166.7e-3
rj648 n903__chipdriverout n904__chipdriverout 166.7e-3
rj649 n905__chipdriverout n906__chipdriverout 166.7e-3
rj650 n907__chipdriverout n908__chipdriverout 166.7e-3
rj651 n909__chipdriverout n910__chipdriverout 166.7e-3
rj652 n911__chipdriverout n912__chipdriverout 166.7e-3
rj653 n913__chipdriverout n914__chipdriverout 166.7e-3
rj654 n915__chipdriverout n916__chipdriverout 166.7e-3
rj655 n917__chipdriverout n918__chipdriverout 166.7e-3
rj656 n919__chipdriverout n920__chipdriverout 166.7e-3
rj657 n921__chipdriverout n922__chipdriverout 166.7e-3
rj658 n425__i0__i14__net1 n427__i0__i14__net1 125e-3
rj659 n427__i0__i14__net1 n426__i0__i14__net1 125e-3
rj660 n300__vss n301__vss 166.7e-3
rj661 n302__vss n303__vss 166.7e-3
rj662 n304__vss n305__vss 166.7e-3
rj663 n306__vss n307__vss 166.7e-3
rj664 n485__vddio n498__vddio 166.7e-3
rj665 n499__vddio n488__vddio 166.7e-3
rj666 n489__vddio n500__vddio 166.7e-3
rj667 n501__vddio n491__vddio 166.7e-3
rj668 n492__vddio n502__vddio 166.7e-3
rj669 n503__vddio n494__vddio 166.7e-3
rj670 n495__vddio n504__vddio 166.7e-3
rj671 n439__i0__i14__net1 n437__i0__i14__net1 125e-3
rj672 n438__i0__i14__net1 n439__i0__i14__net1 125e-3
rj673 n939__chipdriverout n962__chipdriverout 166.7e-3
rj674 n963__chipdriverout n940__chipdriverout 166.7e-3
rj675 n942__chipdriverout n964__chipdriverout 166.7e-3
rj676 n965__chipdriverout n943__chipdriverout 166.7e-3
rj677 n945__chipdriverout n966__chipdriverout 166.7e-3
rj678 n967__chipdriverout n948__chipdriverout 166.7e-3
rj679 n951__chipdriverout n968__chipdriverout 166.7e-3
rj680 n969__chipdriverout n952__chipdriverout 166.7e-3
rj681 n954__chipdriverout n970__chipdriverout 166.7e-3
rj682 n971__chipdriverout n955__chipdriverout 166.7e-3
rj683 n957__chipdriverout n972__chipdriverout 166.7e-3
rj684 n973__chipdriverout n958__chipdriverout 166.7e-3
rj685 n960__chipdriverout n974__chipdriverout 166.7e-3
rj686 n441__i0__i14__net1 n443__i0__i14__net1 125e-3
rj687 n443__i0__i14__net1 n442__i0__i14__net1 125e-3
rj688 n313__vss n314__vss 166.7e-3
rj689 n315__vss n316__vss 166.7e-3
rj690 n317__vss n318__vss 166.7e-3
rj691 n319__vss n320__vss 166.7e-3
rj692 n506__vddio n519__vddio 166.7e-3
rj693 n520__vddio n509__vddio 166.7e-3
rj694 n510__vddio n521__vddio 166.7e-3
rj695 n522__vddio n512__vddio 166.7e-3
rj696 n513__vddio n523__vddio 166.7e-3
rj697 n524__vddio n515__vddio 166.7e-3
rj698 n516__vddio n525__vddio 166.7e-3
rj699 n455__i0__i14__net1 n453__i0__i14__net1 125e-3
rj700 n454__i0__i14__net1 n455__i0__i14__net1 125e-3
rj701 n978__chipdriverout n1001__chipdriverout 166.7e-3
rj702 n1002__chipdriverout n979__chipdriverout 166.7e-3
rj703 n981__chipdriverout n1003__chipdriverout 166.7e-3
rj704 n1004__chipdriverout n982__chipdriverout 166.7e-3
rj705 n984__chipdriverout n1005__chipdriverout 166.7e-3
rj706 n1006__chipdriverout n987__chipdriverout 166.7e-3
rj707 n990__chipdriverout n1007__chipdriverout 166.7e-3
rj708 n1008__chipdriverout n991__chipdriverout 166.7e-3
rj709 n993__chipdriverout n1009__chipdriverout 166.7e-3
rj710 n1010__chipdriverout n994__chipdriverout 166.7e-3
rj711 n996__chipdriverout n1011__chipdriverout 166.7e-3
rj712 n1012__chipdriverout n997__chipdriverout 166.7e-3
rj713 n999__chipdriverout n1013__chipdriverout 166.7e-3
rj714 n346__i0__i14__net1 n458__i0__i14__net1 250e-3
rj715 n458__i0__i14__net1 n348__i0__i14__net1 250e-3
rj716 n326__vss n327__vss 166.7e-3
rj717 n328__vss n329__vss 166.7e-3
rj718 n330__vss n331__vss 166.7e-3
rj719 n332__vss n333__vss 166.7e-3
rj720 n526__vddio n527__vddio 166.7e-3
rj721 n528__vddio n529__vddio 166.7e-3
rj722 n530__vddio n531__vddio 166.7e-3
rj723 n532__vddio n533__vddio 166.7e-3
rj724 n534__vddio n535__vddio 166.7e-3
rj725 n536__vddio n537__vddio 166.7e-3
rj726 n538__vddio n539__vddio 166.7e-3
rj727 n471__i0__i14__net1 n469__i0__i14__net1 125e-3
rj728 n470__i0__i14__net1 n471__i0__i14__net1 125e-3
rj729 n1017__chipdriverout n1040__chipdriverout 166.7e-3
rj730 n1041__chipdriverout n1018__chipdriverout 166.7e-3
rj731 n1020__chipdriverout n1042__chipdriverout 166.7e-3
rj732 n1043__chipdriverout n1021__chipdriverout 166.7e-3
rj733 n1023__chipdriverout n1044__chipdriverout 166.7e-3
rj734 n1045__chipdriverout n1026__chipdriverout 166.7e-3
rj735 n1029__chipdriverout n1046__chipdriverout 166.7e-3
rj736 n1047__chipdriverout n1030__chipdriverout 166.7e-3
rj737 n1032__chipdriverout n1048__chipdriverout 166.7e-3
rj738 n1049__chipdriverout n1033__chipdriverout 166.7e-3
rj739 n1035__chipdriverout n1050__chipdriverout 166.7e-3
rj740 n1051__chipdriverout n1036__chipdriverout 166.7e-3
rj741 n1038__chipdriverout n1052__chipdriverout 166.7e-3
rj742 n473__i0__i14__net1 n475__i0__i14__net1 125e-3
rj743 n475__i0__i14__net1 n474__i0__i14__net1 125e-3
rj744 n345__vss n348__vss 166.7e-3
rj745 n349__vss n344__vss 166.7e-3
rj746 n342__vss n350__vss 166.7e-3
rj747 n351__vss n341__vss 166.7e-3
rj748 n548__vddio n561__vddio 166.7e-3
rj749 n562__vddio n551__vddio 166.7e-3
rj750 n552__vddio n563__vddio 166.7e-3
rj751 n564__vddio n554__vddio 166.7e-3
rj752 n555__vddio n565__vddio 166.7e-3
rj753 n566__vddio n557__vddio 166.7e-3
rj754 n558__vddio n567__vddio 166.7e-3
rj755 n485__i0__i14__net1 n373__i0__i14__net1 250e-3
rj756 n375__i0__i14__net1 n485__i0__i14__net1 250e-3
rj757 n1056__chipdriverout n1079__chipdriverout 166.7e-3
rj758 n1080__chipdriverout n1057__chipdriverout 166.7e-3
rj759 n1059__chipdriverout n1081__chipdriverout 166.7e-3
rj760 n1082__chipdriverout n1060__chipdriverout 166.7e-3
rj761 n1062__chipdriverout n1083__chipdriverout 166.7e-3
rj762 n1084__chipdriverout n1065__chipdriverout 166.7e-3
rj763 n1068__chipdriverout n1085__chipdriverout 166.7e-3
rj764 n1086__chipdriverout n1069__chipdriverout 166.7e-3
rj765 n1071__chipdriverout n1087__chipdriverout 166.7e-3
rj766 n1088__chipdriverout n1072__chipdriverout 166.7e-3
rj767 n1074__chipdriverout n1089__chipdriverout 166.7e-3
rj768 n1090__chipdriverout n1075__chipdriverout 166.7e-3
rj769 n1077__chipdriverout n1091__chipdriverout 166.7e-3
rj770 n378__i0__i14__net1 n494__i0__i14__net1 250e-3
rj771 n494__i0__i14__net1 n380__i0__i14__net1 250e-3
rj772 n352__vss n353__vss 166.7e-3
rj773 n354__vss n355__vss 166.7e-3
rj774 n356__vss n357__vss 166.7e-3
rj775 n358__vss n359__vss 166.7e-3
rj776 n568__vddio n569__vddio 166.7e-3
rj777 n570__vddio n571__vddio 166.7e-3
rj778 n572__vddio n573__vddio 166.7e-3
rj779 n574__vddio n575__vddio 166.7e-3
rj780 n576__vddio n577__vddio 166.7e-3
rj781 n578__vddio n579__vddio 166.7e-3
rj782 n580__vddio n581__vddio 166.7e-3
rj783 n503__i0__i14__net1 n501__i0__i14__net1 125e-3
rj784 n502__i0__i14__net1 n503__i0__i14__net1 125e-3
rj785 n1092__chipdriverout n1093__chipdriverout 166.7e-3
rj786 n1094__chipdriverout n1095__chipdriverout 166.7e-3
rj787 n1096__chipdriverout n1097__chipdriverout 166.7e-3
rj788 n1098__chipdriverout n1099__chipdriverout 166.7e-3
rj789 n1100__chipdriverout n1101__chipdriverout 166.7e-3
rj790 n1102__chipdriverout n1103__chipdriverout 166.7e-3
rj791 n1104__chipdriverout n1105__chipdriverout 166.7e-3
rj792 n1106__chipdriverout n1107__chipdriverout 166.7e-3
rj793 n1108__chipdriverout n1109__chipdriverout 166.7e-3
rj794 n1110__chipdriverout n1111__chipdriverout 166.7e-3
rj795 n1112__chipdriverout n1113__chipdriverout 166.7e-3
rj796 n1114__chipdriverout n1115__chipdriverout 166.7e-3
rj797 n1116__chipdriverout n1117__chipdriverout 166.7e-3
rj798 n509__i0__i14__net1 n511__i0__i14__net1 125e-3
rj799 n511__i0__i14__net1 n510__i0__i14__net1 125e-3
rj800 n371__vss n374__vss 166.7e-3
rj801 n375__vss n370__vss 166.7e-3
rj802 n368__vss n376__vss 166.7e-3
rj803 n377__vss n367__vss 166.7e-3
rj804 n590__vddio n603__vddio 166.7e-3
rj805 n604__vddio n593__vddio 166.7e-3
rj806 n594__vddio n605__vddio 166.7e-3
rj807 n606__vddio n596__vddio 166.7e-3
rj808 n597__vddio n607__vddio 166.7e-3
rj809 n608__vddio n599__vddio 166.7e-3
rj810 n600__vddio n609__vddio 166.7e-3
rj811 n519__i0__i14__net1 n517__i0__i14__net1 125e-3
rj812 n518__i0__i14__net1 n519__i0__i14__net1 125e-3
rj813 n1131__chipdriverout n1132__chipdriverout 166.7e-3
rj814 n1133__chipdriverout n1134__chipdriverout 166.7e-3
rj815 n1135__chipdriverout n1136__chipdriverout 166.7e-3
rj816 n1137__chipdriverout n1138__chipdriverout 166.7e-3
rj817 n1139__chipdriverout n1140__chipdriverout 166.7e-3
rj818 n1141__chipdriverout n1142__chipdriverout 166.7e-3
rj819 n1143__chipdriverout n1144__chipdriverout 166.7e-3
rj820 n1145__chipdriverout n1146__chipdriverout 166.7e-3
rj821 n1147__chipdriverout n1148__chipdriverout 166.7e-3
rj822 n1149__chipdriverout n1150__chipdriverout 166.7e-3
rj823 n1151__chipdriverout n1152__chipdriverout 166.7e-3
rj824 n1153__chipdriverout n1154__chipdriverout 166.7e-3
rj825 n1155__chipdriverout n1156__chipdriverout 166.7e-3
rj826 n525__i0__i14__net1 n527__i0__i14__net1 125e-3
rj827 n527__i0__i14__net1 n526__i0__i14__net1 125e-3
rj828 n378__vss n379__vss 166.7e-3
rj829 n380__vss n381__vss 166.7e-3
rj830 n382__vss n383__vss 166.7e-3
rj831 n384__vss n385__vss 166.7e-3
rj832 n610__vddio n611__vddio 166.7e-3
rj833 n612__vddio n613__vddio 166.7e-3
rj834 n614__vddio n615__vddio 166.7e-3
rj835 n616__vddio n617__vddio 166.7e-3
rj836 n618__vddio n619__vddio 166.7e-3
rj837 n620__vddio n621__vddio 166.7e-3
rj838 n622__vddio n623__vddio 166.7e-3
rj839 n535__i0__i14__net1 n533__i0__i14__net1 125e-3
rj840 n534__i0__i14__net1 n535__i0__i14__net1 125e-3
rj841 n1173__chipdriverout n1196__chipdriverout 166.7e-3
rj842 n1197__chipdriverout n1174__chipdriverout 166.7e-3
rj843 n1176__chipdriverout n1198__chipdriverout 166.7e-3
rj844 n1199__chipdriverout n1177__chipdriverout 166.7e-3
rj845 n1179__chipdriverout n1200__chipdriverout 166.7e-3
rj846 n1201__chipdriverout n1182__chipdriverout 166.7e-3
rj847 n1185__chipdriverout n1202__chipdriverout 166.7e-3
rj848 n1203__chipdriverout n1186__chipdriverout 166.7e-3
rj849 n1188__chipdriverout n1204__chipdriverout 166.7e-3
rj850 n1205__chipdriverout n1189__chipdriverout 166.7e-3
rj851 n1191__chipdriverout n1206__chipdriverout 166.7e-3
rj852 n1207__chipdriverout n1192__chipdriverout 166.7e-3
rj853 n1194__chipdriverout n1208__chipdriverout 166.7e-3
rj854 n430__i0__i14__net1 n538__i0__i14__net1 250e-3
rj855 n538__i0__i14__net1 n432__i0__i14__net1 250e-3
rj856 n397__vss n400__vss 166.7e-3
rj857 n401__vss n396__vss 166.7e-3
rj858 n394__vss n402__vss 166.7e-3
rj859 n403__vss n393__vss 166.7e-3
rj860 n632__vddio n645__vddio 166.7e-3
rj861 n646__vddio n635__vddio 166.7e-3
rj862 n636__vddio n647__vddio 166.7e-3
rj863 n648__vddio n638__vddio 166.7e-3
rj864 n639__vddio n649__vddio 166.7e-3
rj865 n650__vddio n641__vddio 166.7e-3
rj866 n642__vddio n651__vddio 166.7e-3
rj867 n551__i0__i14__net1 n549__i0__i14__net1 125e-3
rj868 n550__i0__i14__net1 n551__i0__i14__net1 125e-3
rj869 n1212__chipdriverout n1235__chipdriverout 166.7e-3
rj870 n1236__chipdriverout n1213__chipdriverout 166.7e-3
rj871 n1215__chipdriverout n1237__chipdriverout 166.7e-3
rj872 n1238__chipdriverout n1216__chipdriverout 166.7e-3
rj873 n1218__chipdriverout n1239__chipdriverout 166.7e-3
rj874 n1240__chipdriverout n1221__chipdriverout 166.7e-3
rj875 n1224__chipdriverout n1241__chipdriverout 166.7e-3
rj876 n1242__chipdriverout n1225__chipdriverout 166.7e-3
rj877 n1227__chipdriverout n1243__chipdriverout 166.7e-3
rj878 n1244__chipdriverout n1228__chipdriverout 166.7e-3
rj879 n1230__chipdriverout n1245__chipdriverout 166.7e-3
rj880 n1246__chipdriverout n1231__chipdriverout 166.7e-3
rj881 n1233__chipdriverout n1247__chipdriverout 166.7e-3
rj882 n446__i0__i14__net1 n554__i0__i14__net1 250e-3
rj883 n554__i0__i14__net1 n448__i0__i14__net1 250e-3
rj884 n404__vss n405__vss 166.7e-3
rj885 n406__vss n407__vss 166.7e-3
rj886 n408__vss n409__vss 166.7e-3
rj887 n410__vss n411__vss 166.7e-3
rj888 n652__vddio n653__vddio 166.7e-3
rj889 n654__vddio n655__vddio 166.7e-3
rj890 n656__vddio n657__vddio 166.7e-3
rj891 n658__vddio n659__vddio 166.7e-3
rj892 n660__vddio n661__vddio 166.7e-3
rj893 n662__vddio n663__vddio 166.7e-3
rj894 n664__vddio n665__vddio 166.7e-3
rj895 n565__i0__i14__net1 n450__i0__i14__net1 250e-3
rj896 n452__i0__i14__net1 n565__i0__i14__net1 250e-3
rj897 n19__clk n16__clk 1
rj898 n18__clk n20__clk 1
rj899 n1251__chipdriverout n1274__chipdriverout 166.7e-3
rj900 n1275__chipdriverout n1252__chipdriverout 166.7e-3
rj901 n1254__chipdriverout n1276__chipdriverout 166.7e-3
rj902 n1277__chipdriverout n1255__chipdriverout 166.7e-3
rj903 n1257__chipdriverout n1278__chipdriverout 166.7e-3
rj904 n1279__chipdriverout n1260__chipdriverout 166.7e-3
rj905 n1263__chipdriverout n1280__chipdriverout 166.7e-3
rj906 n1281__chipdriverout n1264__chipdriverout 166.7e-3
rj907 n1266__chipdriverout n1282__chipdriverout 166.7e-3
rj908 n1283__chipdriverout n1267__chipdriverout 166.7e-3
rj909 n1269__chipdriverout n1284__chipdriverout 166.7e-3
rj910 n1285__chipdriverout n1270__chipdriverout 166.7e-3
rj911 n1272__chipdriverout n1286__chipdriverout 166.7e-3
rj912 n571__i0__i14__net1 n569__i0__i14__net1 125e-3
rj913 n570__i0__i14__net1 n571__i0__i14__net1 125e-3
rj914 n417__vss n418__vss 1.948
rj915 n8__i3__net10 n6__i3__net10 1
rj916 n6__i1__net1 n8__i1__net1 1
rj917 n419__vss n420__vss 166.7e-3
rj918 n421__vss n422__vss 166.7e-3
rj919 n423__vss n424__vss 166.7e-3
rj920 n425__vss n426__vss 166.7e-3
rj921 n687__vddio n674__vddio 166.7e-3
rj922 n677__vddio n688__vddio 166.7e-3
rj923 n689__vddio n678__vddio 166.7e-3
rj924 n680__vddio n690__vddio 166.7e-3
rj925 n691__vddio n681__vddio 166.7e-3
rj926 n683__vddio n692__vddio 166.7e-3
rj927 n693__vddio n684__vddio 166.7e-3
rj928 n581__i0__i14__net1 n583__i0__i14__net1 125e-3
rj929 n583__i0__i14__net1 n582__i0__i14__net1 125e-3
rj930 n7__i3__net9 n6__i3__net9 500e-3
rj931 n1287__chipdriverout n1288__chipdriverout 166.7e-3
rj932 n1289__chipdriverout n1290__chipdriverout 166.7e-3
rj933 n1291__chipdriverout n1292__chipdriverout 166.7e-3
rj934 n1293__chipdriverout n1294__chipdriverout 166.7e-3
rj935 n1295__chipdriverout n1296__chipdriverout 166.7e-3
rj936 n1297__chipdriverout n1298__chipdriverout 166.7e-3
rj937 n1299__chipdriverout n1300__chipdriverout 166.7e-3
rj938 n1301__chipdriverout n1302__chipdriverout 166.7e-3
rj939 n1303__chipdriverout n1304__chipdriverout 166.7e-3
rj940 n1305__chipdriverout n1306__chipdriverout 166.7e-3
rj941 n1307__chipdriverout n1308__chipdriverout 166.7e-3
rj942 n1309__chipdriverout n1310__chipdriverout 166.7e-3
rj943 n1311__chipdriverout n1312__chipdriverout 166.7e-3
rj944 n587__i0__i14__net1 n585__i0__i14__net1 125e-3
rj945 n586__i0__i14__net1 n587__i0__i14__net1 125e-3
rj946 n432__vss n433__vss 166.7e-3
rj947 n434__vss n435__vss 166.7e-3
rj948 n436__vss n437__vss 166.7e-3
rj949 n438__vss n439__vss 166.7e-3
rj950 n708__vddio n695__vddio 166.7e-3
rj951 n698__vddio n709__vddio 166.7e-3
rj952 n710__vddio n699__vddio 166.7e-3
rj953 n701__vddio n711__vddio 166.7e-3
rj954 n712__vddio n702__vddio 166.7e-3
rj955 n704__vddio n713__vddio 166.7e-3
rj956 n714__vddio n705__vddio 166.7e-3
rj957 n1__vdd n2__vdd 1.5077
rj958 n15__s n13__s 1.0568
rj959 n13__s n12__s 500e-3
rj960 n599__i0__i14__net1 n597__i0__i14__net1 125e-3
rj961 n598__i0__i14__net1 n599__i0__i14__net1 125e-3
rj962 n1329__chipdriverout n1352__chipdriverout 166.7e-3
rj963 n1353__chipdriverout n1330__chipdriverout 166.7e-3
rj964 n1332__chipdriverout n1354__chipdriverout 166.7e-3
rj965 n1355__chipdriverout n1333__chipdriverout 166.7e-3
rj966 n1335__chipdriverout n1356__chipdriverout 166.7e-3
rj967 n1357__chipdriverout n1338__chipdriverout 166.7e-3
rj968 n1341__chipdriverout n1358__chipdriverout 166.7e-3
rj969 n1359__chipdriverout n1342__chipdriverout 166.7e-3
rj970 n1344__chipdriverout n1360__chipdriverout 166.7e-3
rj971 n1361__chipdriverout n1345__chipdriverout 166.7e-3
rj972 n1347__chipdriverout n1362__chipdriverout 166.7e-3
rj973 n1363__chipdriverout n1348__chipdriverout 166.7e-3
rj974 n1350__chipdriverout n1364__chipdriverout 166.7e-3
rj975 n605__i0__i14__net1 n607__i0__i14__net1 125e-3
rj976 n607__i0__i14__net1 n606__i0__i14__net1 125e-3
rj977 n2__r2 n4__r2 1
rj978 n451__vss n454__vss 166.7e-3
rj979 n455__vss n450__vss 166.7e-3
rj980 n448__vss n456__vss 166.7e-3
rj981 n457__vss n447__vss 166.7e-3
rj982 n716__vddio n729__vddio 166.7e-3
rj983 n730__vddio n719__vddio 166.7e-3
rj984 n720__vddio n731__vddio 166.7e-3
rj985 n732__vddio n722__vddio 166.7e-3
rj986 n723__vddio n733__vddio 166.7e-3
rj987 n734__vddio n725__vddio 166.7e-3
rj988 n726__vddio n735__vddio 166.7e-3
rj989 n613__i0__i14__net1 n615__i0__i14__net1 125e-3
rj990 n615__i0__i14__net1 n614__i0__i14__net1 125e-3
rj991 n12__i1__net3 n6__i1__net3 1.0491
rj992 n1391__chipdriverout n1368__chipdriverout 166.7e-3
rj993 n1369__chipdriverout n1392__chipdriverout 166.7e-3
rj994 n1393__chipdriverout n1371__chipdriverout 166.7e-3
rj995 n1372__chipdriverout n1394__chipdriverout 166.7e-3
rj996 n1395__chipdriverout n1374__chipdriverout 166.7e-3
rj997 n1377__chipdriverout n1396__chipdriverout 166.7e-3
rj998 n1397__chipdriverout n1380__chipdriverout 166.7e-3
rj999 n1381__chipdriverout n1398__chipdriverout 166.7e-3
rj1000 n1399__chipdriverout n1383__chipdriverout 166.7e-3
rj1001 n1384__chipdriverout n1400__chipdriverout 166.7e-3
rj1002 n1401__chipdriverout n1386__chipdriverout 166.7e-3
rj1003 n1387__chipdriverout n1402__chipdriverout 166.7e-3
rj1004 n1403__chipdriverout n1389__chipdriverout 166.7e-3
rj1005 n506__i0__i14__net1 n622__i0__i14__net1 250e-3
rj1006 n622__i0__i14__net1 n508__i0__i14__net1 250e-3
rj1007 n22__clk n21__clk 1.6316
rj1009 n11__i3__net10 n9__i3__net10 1.5627
rj1010 n9__i3__net10 n10__i3__net10 13.11e-3
rj1011 n15__i1__net3 n14__i1__net3 1.0019
rj1012 n464__vss n467__vss 166.7e-3
rj1013 n468__vss n463__vss 166.7e-3
rj1014 n461__vss n469__vss 166.7e-3
rj1015 n470__vss n460__vss 166.7e-3
rj1016 n737__vddio n750__vddio 166.7e-3
rj1017 n751__vddio n740__vddio 166.7e-3
rj1018 n741__vddio n752__vddio 166.7e-3
rj1019 n753__vddio n743__vddio 166.7e-3
rj1020 n744__vddio n754__vddio 166.7e-3
rj1021 n755__vddio n746__vddio 166.7e-3
rj1022 n747__vddio n756__vddio 166.7e-3
rj1023 n629__i0__i14__net1 n631__i0__i14__net1 125e-3
rj1024 n631__i0__i14__net1 n630__i0__i14__net1 125e-3
rj1025 n1407__chipdriverout n1430__chipdriverout 166.7e-3
rj1026 n1431__chipdriverout n1408__chipdriverout 166.7e-3
rj1027 n1410__chipdriverout n1432__chipdriverout 166.7e-3
rj1028 n1433__chipdriverout n1411__chipdriverout 166.7e-3
rj1029 n1413__chipdriverout n1434__chipdriverout 166.7e-3
rj1030 n1435__chipdriverout n1416__chipdriverout 166.7e-3
rj1031 n1419__chipdriverout n1436__chipdriverout 166.7e-3
rj1032 n1437__chipdriverout n1420__chipdriverout 166.7e-3
rj1033 n1422__chipdriverout n1438__chipdriverout 166.7e-3
rj1034 n1439__chipdriverout n1423__chipdriverout 166.7e-3
rj1035 n1425__chipdriverout n1440__chipdriverout 166.7e-3
rj1036 n1441__chipdriverout n1426__chipdriverout 166.7e-3
rj1037 n1428__chipdriverout n1442__chipdriverout 166.7e-3
rj1038 n637__i0__i14__net1 n639__i0__i14__net1 125e-3
rj1039 n639__i0__i14__net1 n638__i0__i14__net1 125e-3
rj1040 n477__vss n480__vss 166.7e-3
rj1041 n481__vss n476__vss 166.7e-3
rj1042 n474__vss n482__vss 166.7e-3
rj1043 n483__vss n473__vss 166.7e-3
rj1044 n758__vddio n771__vddio 166.7e-3
rj1045 n772__vddio n761__vddio 166.7e-3
rj1046 n762__vddio n773__vddio 166.7e-3
rj1047 n774__vddio n764__vddio 166.7e-3
rj1048 n765__vddio n775__vddio 166.7e-3
rj1049 n776__vddio n767__vddio 166.7e-3
rj1050 n768__vddio n777__vddio 166.7e-3
rj1051 n10__i3__net9 n8__i3__net9 500e-3
rj1052 n641__i0__i14__net1 n643__i0__i14__net1 125e-3
rj1053 n643__i0__i14__net1 n642__i0__i14__net1 125e-3
rj1054 n1469__chipdriverout n1446__chipdriverout 166.7e-3
rj1055 n1447__chipdriverout n1470__chipdriverout 166.7e-3
rj1056 n1471__chipdriverout n1449__chipdriverout 166.7e-3
rj1057 n1450__chipdriverout n1472__chipdriverout 166.7e-3
rj1058 n1473__chipdriverout n1452__chipdriverout 166.7e-3
rj1059 n1455__chipdriverout n1474__chipdriverout 166.7e-3
rj1060 n1475__chipdriverout n1458__chipdriverout 166.7e-3
rj1061 n1459__chipdriverout n1476__chipdriverout 166.7e-3
rj1062 n1477__chipdriverout n1461__chipdriverout 166.7e-3
rj1063 n1462__chipdriverout n1478__chipdriverout 166.7e-3
rj1064 n1479__chipdriverout n1464__chipdriverout 166.7e-3
rj1065 n1465__chipdriverout n1480__chipdriverout 166.7e-3
rj1066 n1481__chipdriverout n1467__chipdriverout 166.7e-3
rj1068 n23__i3__net13 n20__i3__net13 284.3e-3
rj1069 n22__i3__net13 n23__i3__net13 500e-3
rj1070 n649__i0__i14__net1 n542__i0__i14__net1 250e-3
rj1071 n544__i0__i14__net1 n649__i0__i14__net1 250e-3
rj1072 n6__i3__net12 n8__i3__net12 1
rj1073 n490__vss n493__vss 166.7e-3
rj1074 n494__vss n489__vss 166.7e-3
rj1075 n487__vss n495__vss 166.7e-3
rj1076 n496__vss n486__vss 166.7e-3
rj1077 n779__vddio n792__vddio 166.7e-3
rj1078 n793__vddio n782__vddio 166.7e-3
rj1079 n783__vddio n794__vddio 166.7e-3
rj1080 n795__vddio n785__vddio 166.7e-3
rj1081 n786__vddio n796__vddio 166.7e-3
rj1082 n797__vddio n788__vddio 166.7e-3
rj1083 n789__vddio n798__vddio 166.7e-3
rj1084 n661__i0__i14__net1 n663__i0__i14__net1 125e-3
rj1085 n663__i0__i14__net1 n662__i0__i14__net1 125e-3
rj1086 n1485__chipdriverout n1508__chipdriverout 166.7e-3
rj1087 n1509__chipdriverout n1486__chipdriverout 166.7e-3
rj1088 n1488__chipdriverout n1510__chipdriverout 166.7e-3
rj1089 n1511__chipdriverout n1489__chipdriverout 166.7e-3
rj1090 n1491__chipdriverout n1512__chipdriverout 166.7e-3
rj1091 n1513__chipdriverout n1494__chipdriverout 166.7e-3
rj1092 n1497__chipdriverout n1514__chipdriverout 166.7e-3
rj1093 n1515__chipdriverout n1498__chipdriverout 166.7e-3
rj1094 n1500__chipdriverout n1516__chipdriverout 166.7e-3
rj1095 n1517__chipdriverout n1501__chipdriverout 166.7e-3
rj1096 n1503__chipdriverout n1518__chipdriverout 166.7e-3
rj1097 n1519__chipdriverout n1504__chipdriverout 166.7e-3
rj1098 n1506__chipdriverout n1520__chipdriverout 166.7e-3
rj1099 n7__i3__net11 n6__i3__net11 500e-3
rj1100 n27__clk n26__clk 1.6189
rj1101 n26__clk n28__clk 500e-3
rj1102 n12__i1__net1 n11__i1__net1 1.5652
rj1104 n558__i0__i14__net1 n666__i0__i14__net1 250e-3
rj1105 n666__i0__i14__net1 n560__i0__i14__net1 250e-3
rj1106 n506__vss n503__vss 166.7e-3
rj1107 n502__vss n507__vss 166.7e-3
rj1108 n508__vss n500__vss 166.7e-3
rj1109 n499__vss n509__vss 166.7e-3
rj1110 n813__vddio n800__vddio 166.7e-3
rj1111 n803__vddio n814__vddio 166.7e-3
rj1112 n815__vddio n804__vddio 166.7e-3
rj1113 n806__vddio n816__vddio 166.7e-3
rj1114 n817__vddio n807__vddio 166.7e-3
rj1115 n809__vddio n818__vddio 166.7e-3
rj1116 n819__vddio n810__vddio 166.7e-3
rj1117 n3__reset n4__reset 1.0974
rj1118 n677__i0__i14__net1 n679__i0__i14__net1 125e-3
rj1119 n679__i0__i14__net1 n678__i0__i14__net1 125e-3
rj1120 n1560__chipdriverout n1537__chipdriverout 166.7e-3
rj1121 n1538__chipdriverout n1561__chipdriverout 166.7e-3
rj1122 n1562__chipdriverout n1540__chipdriverout 166.7e-3
rj1123 n1541__chipdriverout n1563__chipdriverout 166.7e-3
rj1124 n1564__chipdriverout n1543__chipdriverout 166.7e-3
rj1125 n1546__chipdriverout n1565__chipdriverout 166.7e-3
rj1126 n1566__chipdriverout n1549__chipdriverout 166.7e-3
rj1127 n1550__chipdriverout n1567__chipdriverout 166.7e-3
rj1128 n1568__chipdriverout n1552__chipdriverout 166.7e-3
rj1129 n1553__chipdriverout n1569__chipdriverout 166.7e-3
rj1130 n1570__chipdriverout n1555__chipdriverout 166.7e-3
rj1131 n1556__chipdriverout n1571__chipdriverout 166.7e-3
rj1132 n1572__chipdriverout n1558__chipdriverout 166.7e-3
rj1133 n683__i0__i14__net1 n681__i0__i14__net1 125e-3
rj1134 n682__i0__i14__net1 n683__i0__i14__net1 125e-3
rj1135 n6__i1__net4 n2__i1__net4 1.0038
rj1136 n516__vss n519__vss 166.7e-3
rj1137 n520__vss n515__vss 166.7e-3
rj1138 n513__vss n521__vss 166.7e-3
rj1139 n522__vss n512__vss 166.7e-3
rj1140 n821__vddio n834__vddio 166.7e-3
rj1141 n835__vddio n824__vddio 166.7e-3
rj1142 n825__vddio n836__vddio 166.7e-3
rj1143 n837__vddio n827__vddio 166.7e-3
rj1144 n828__vddio n838__vddio 166.7e-3
rj1145 n839__vddio n830__vddio 166.7e-3
rj1146 n831__vddio n840__vddio 166.7e-3
rj1147 n695__i0__i14__net1 n693__i0__i14__net1 125e-3
rj1148 n694__i0__i14__net1 n695__i0__i14__net1 125e-3
rj1149 n1599__chipdriverout n1576__chipdriverout 166.7e-3
rj1150 n1577__chipdriverout n1600__chipdriverout 166.7e-3
rj1151 n1601__chipdriverout n1579__chipdriverout 166.7e-3
rj1152 n1580__chipdriverout n1602__chipdriverout 166.7e-3
rj1153 n1603__chipdriverout n1582__chipdriverout 166.7e-3
rj1154 n1585__chipdriverout n1604__chipdriverout 166.7e-3
rj1155 n1605__chipdriverout n1588__chipdriverout 166.7e-3
rj1156 n1589__chipdriverout n1606__chipdriverout 166.7e-3
rj1157 n1607__chipdriverout n1591__chipdriverout 166.7e-3
rj1158 n1592__chipdriverout n1608__chipdriverout 166.7e-3
rj1159 n1609__chipdriverout n1594__chipdriverout 166.7e-3
rj1160 n1595__chipdriverout n1610__chipdriverout 166.7e-3
rj1161 n1611__chipdriverout n1597__chipdriverout 166.7e-3
rj1162 n699__i0__i14__net1 n697__i0__i14__net1 125e-3
rj1163 n698__i0__i14__net1 n699__i0__i14__net1 125e-3
rj1164 n8__i1__net4 n7__i1__net4 563.7e-3
rj1165 n529__vss n532__vss 166.7e-3
rj1166 n533__vss n528__vss 166.7e-3
rj1167 n526__vss n534__vss 166.7e-3
rj1168 n535__vss n525__vss 166.7e-3
rj1169 n842__vddio n855__vddio 166.7e-3
rj1170 n856__vddio n845__vddio 166.7e-3
rj1171 n846__vddio n857__vddio 166.7e-3
rj1172 n858__vddio n848__vddio 166.7e-3
rj1173 n849__vddio n859__vddio 166.7e-3
rj1174 n860__vddio n851__vddio 166.7e-3
rj1175 n852__vddio n861__vddio 166.7e-3
rj1176 n27__i3__net13 n25__i3__net13 1.6175
rj1178 n11__i3__net12 n9__i3__net12 2.0627
rj1179 n9__i3__net12 n10__i3__net12 13.11e-3
rj1180 n27__s n25__s 1.0568
rj1181 n25__s n24__s 500e-3
rj1182 n711__i0__i14__net1 n709__i0__i14__net1 125e-3
rj1183 n710__i0__i14__net1 n711__i0__i14__net1 125e-3
rj1184 n1630__chipdriverout n1638__chipdriverout 166.7e-3
rj1185 n1639__chipdriverout n1631__chipdriverout 166.7e-3
rj1186 n1633__chipdriverout n1640__chipdriverout 166.7e-3
rj1187 n1641__chipdriverout n1634__chipdriverout 166.7e-3
rj1188 n1636__chipdriverout n1642__chipdriverout 166.7e-3
rj1189 n1643__chipdriverout n1613__chipdriverout 166.7e-3
rj1190 n1616__chipdriverout n1644__chipdriverout 166.7e-3
rj1191 n1645__chipdriverout n1617__chipdriverout 166.7e-3
rj1192 n1619__chipdriverout n1646__chipdriverout 166.7e-3
rj1193 n1647__chipdriverout n1620__chipdriverout 166.7e-3
rj1194 n1622__chipdriverout n1648__chipdriverout 166.7e-3
rj1195 n1649__chipdriverout n1623__chipdriverout 166.7e-3
rj1196 n1625__chipdriverout n1650__chipdriverout 166.7e-3
rj1197 n719__i0__i14__net1 n717__i0__i14__net1 125e-3
rj1198 n718__i0__i14__net1 n719__i0__i14__net1 125e-3
rj1199 n1__r1 n2__r1 1
rj1200 n536__vss n537__vss 166.7e-3
rj1201 n538__vss n539__vss 166.7e-3
rj1202 n540__vss n541__vss 166.7e-3
rj1203 n542__vss n543__vss 166.7e-3
rj1204 n862__vddio n863__vddio 166.7e-3
rj1205 n864__vddio n865__vddio 166.7e-3
rj1206 n866__vddio n867__vddio 166.7e-3
rj1207 n868__vddio n869__vddio 166.7e-3
rj1208 n870__vddio n871__vddio 166.7e-3
rj1209 n872__vddio n873__vddio 166.7e-3
rj1210 n874__vddio n875__vddio 166.7e-3
rj1211 n9__i3__net11 n11__i3__net11 1
rj1212 n723__i0__i14__net1 n721__i0__i14__net1 125e-3
rj1213 n722__i0__i14__net1 n723__i0__i14__net1 125e-3
rj1214 n12__i1__net5 n6__i1__net5 1.0491
rj1215 n1677__chipdriverout n1669__chipdriverout 166.7e-3
rj1216 n1670__chipdriverout n1678__chipdriverout 166.7e-3
rj1217 n1679__chipdriverout n1672__chipdriverout 166.7e-3
rj1218 n1673__chipdriverout n1680__chipdriverout 166.7e-3
rj1219 n1681__chipdriverout n1675__chipdriverout 166.7e-3
rj1220 n1652__chipdriverout n1682__chipdriverout 166.7e-3
rj1221 n1683__chipdriverout n1655__chipdriverout 166.7e-3
rj1222 n1656__chipdriverout n1684__chipdriverout 166.7e-3
rj1223 n1685__chipdriverout n1658__chipdriverout 166.7e-3
rj1224 n1659__chipdriverout n1686__chipdriverout 166.7e-3
rj1225 n1687__chipdriverout n1661__chipdriverout 166.7e-3
rj1226 n1662__chipdriverout n1688__chipdriverout 166.7e-3
rj1227 n1689__chipdriverout n1664__chipdriverout 166.7e-3
rj1228 n725__i0__i14__net1 n729__i0__i14__net1 125e-3
rj1229 n729__i0__i14__net1 n726__i0__i14__net1 125e-3
rj1230 n15__clk4 n16__clk4 249.1e-3
rj1231 n16__clk4 n10__clk4 742.2e-3
rj1232 n14__clk4 n16__clk4 500e-3
rj1233 n15__i1__net5 n14__i1__net5 501.9e-3
rj1234 n558__vss n555__vss 166.7e-3
rj1235 n554__vss n559__vss 166.7e-3
rj1236 n560__vss n552__vss 166.7e-3
rj1237 n551__vss n561__vss 166.7e-3
rj1238 n897__vddio n884__vddio 166.7e-3
rj1239 n887__vddio n898__vddio 166.7e-3
rj1240 n899__vddio n888__vddio 166.7e-3
rj1241 n890__vddio n900__vddio 166.7e-3
rj1242 n901__vddio n891__vddio 166.7e-3
rj1243 n893__vddio n902__vddio 166.7e-3
rj1244 n903__vddio n894__vddio 166.7e-3
rj1245 n28__i3__net13 n16__i3__net13 3.0728
rj1246 n727__i0__i14__net1 n731__i0__i14__net1 125e-3
rj1247 n731__i0__i14__net1 n728__i0__i14__net1 125e-3
rj1248 n1708__chipdriverout n1716__chipdriverout 166.7e-3
rj1249 n1717__chipdriverout n1709__chipdriverout 166.7e-3
rj1250 n1711__chipdriverout n1718__chipdriverout 166.7e-3
rj1251 n1719__chipdriverout n1712__chipdriverout 166.7e-3
rj1252 n1714__chipdriverout n1720__chipdriverout 166.7e-3
rj1253 n1721__chipdriverout n1691__chipdriverout 166.7e-3
rj1254 n1694__chipdriverout n1722__chipdriverout 166.7e-3
rj1255 n1723__chipdriverout n1695__chipdriverout 166.7e-3
rj1256 n1697__chipdriverout n1724__chipdriverout 166.7e-3
rj1257 n1725__chipdriverout n1698__chipdriverout 166.7e-3
rj1258 n1700__chipdriverout n1726__chipdriverout 166.7e-3
rj1259 n1727__chipdriverout n1701__chipdriverout 166.7e-3
rj1260 n1703__chipdriverout n1728__chipdriverout 166.7e-3
rj1261 n733__i0__i14__net1 n737__i0__i14__net1 125e-3
rj1262 n737__i0__i14__net1 n734__i0__i14__net1 125e-3
rj1263 n568__vss n601__vss 166.7e-3
rj1264 n602__vss n567__vss 166.7e-3
rj1265 n565__vss n603__vss 166.7e-3
rj1266 n604__vss n564__vss 166.7e-3
rj1267 n905__vddio n918__vddio 166.7e-3
rj1268 n919__vddio n908__vddio 166.7e-3
rj1269 n909__vddio n920__vddio 166.7e-3
rj1270 n921__vddio n911__vddio 166.7e-3
rj1271 n912__vddio n922__vddio 166.7e-3
rj1272 n923__vddio n914__vddio 166.7e-3
rj1273 n915__vddio n924__vddio 166.7e-3
rj1274 n739__i0__i14__net1 n735__i0__i14__net1 125e-3
rj1275 n736__i0__i14__net1 n739__i0__i14__net1 125e-3
rj1276 n32__s n33__s 1
rj1277 n1729__chipdriverout n1730__chipdriverout 166.7e-3
rj1278 n1731__chipdriverout n1732__chipdriverout 166.7e-3
rj1279 n1733__chipdriverout n1734__chipdriverout 166.7e-3
rj1280 n1735__chipdriverout n1736__chipdriverout 166.7e-3
rj1281 n1737__chipdriverout n1738__chipdriverout 166.7e-3
rj1282 n1739__chipdriverout n1740__chipdriverout 166.7e-3
rj1283 n1741__chipdriverout n1742__chipdriverout 166.7e-3
rj1284 n1743__chipdriverout n1744__chipdriverout 166.7e-3
rj1285 n1745__chipdriverout n1746__chipdriverout 166.7e-3
rj1286 n1747__chipdriverout n1748__chipdriverout 166.7e-3
rj1287 n1749__chipdriverout n1750__chipdriverout 166.7e-3
rj1288 n1751__chipdriverout n1752__chipdriverout 166.7e-3
rj1289 n1753__chipdriverout n1754__chipdriverout 166.7e-3
rj1290 n741__i0__i14__net1 n654__i0__i14__net1 250e-3
rj1291 n656__i0__i14__net1 n741__i0__i14__net1 250e-3
rj1292 n614__vss n611__vss 166.7e-3
rj1293 n610__vss n615__vss 166.7e-3
rj1294 n616__vss n608__vss 166.7e-3
rj1295 n607__vss n617__vss 166.7e-3
rj1296 n939__vddio n926__vddio 166.7e-3
rj1297 n929__vddio n940__vddio 166.7e-3
rj1298 n941__vddio n930__vddio 166.7e-3
rj1299 n932__vddio n942__vddio 166.7e-3
rj1300 n943__vddio n933__vddio 166.7e-3
rj1301 n935__vddio n944__vddio 166.7e-3
rj1302 n945__vddio n936__vddio 166.7e-3
rj1303 n745__i0__i14__net1 n747__i0__i14__net1 125e-3
rj1304 n747__i0__i14__net1 n746__i0__i14__net1 125e-3
rj1305 n34__clk n33__clk 1.6175
rj1306 n33__clk n35__clk 500e-3
rj1307 n19__i1__net1 n18__i1__net1 2.0655
rj1308 n18__i1__net1 n20__i1__net1 500e-3
rj1309 n1794__chipdriverout n1786__chipdriverout 166.7e-3
rj1310 n1787__chipdriverout n1795__chipdriverout 166.7e-3
rj1311 n1796__chipdriverout n1789__chipdriverout 166.7e-3
rj1312 n1790__chipdriverout n1797__chipdriverout 166.7e-3
rj1313 n1798__chipdriverout n1792__chipdriverout 166.7e-3
rj1314 n1769__chipdriverout n1799__chipdriverout 166.7e-3
rj1315 n1800__chipdriverout n1772__chipdriverout 166.7e-3
rj1316 n1773__chipdriverout n1801__chipdriverout 166.7e-3
rj1317 n1802__chipdriverout n1775__chipdriverout 166.7e-3
rj1318 n1776__chipdriverout n1803__chipdriverout 166.7e-3
rj1319 n1804__chipdriverout n1778__chipdriverout 166.7e-3
rj1320 n1779__chipdriverout n1805__chipdriverout 166.7e-3
rj1321 n1806__chipdriverout n1781__chipdriverout 166.7e-3
rj1322 n749__i0__i14__net1 n670__i0__i14__net1 250e-3
rj1323 n672__i0__i14__net1 n749__i0__i14__net1 250e-3
rj1325 n618__vss n620__vss 1.0491
rj1327 n620__vss n622__vss 1.0491
rj1328 n622__vss n623__vss 25e-3
rj1329 n624__vss n625__vss 166.7e-3
rj1330 n626__vss n627__vss 166.7e-3
rj1331 n628__vss n629__vss 166.7e-3
rj1332 n630__vss n631__vss 166.7e-3
rj1333 n946__vddio n947__vddio 166.7e-3
rj1334 n948__vddio n949__vddio 166.7e-3
rj1335 n950__vddio n951__vddio 166.7e-3
rj1336 n952__vddio n953__vddio 166.7e-3
rj1337 n954__vddio n955__vddio 166.7e-3
rj1338 n956__vddio n957__vddio 166.7e-3
rj1339 n958__vddio n959__vddio 166.7e-3
rj1340 n8__reset n9__reset 1.0974
rj1341 n753__i0__i14__net1 n755__i0__i14__net1 125e-3
rj1342 n755__i0__i14__net1 n754__i0__i14__net1 125e-3
rj1343 n1807__chipdriverout n1808__chipdriverout 166.7e-3
rj1344 n1809__chipdriverout n1810__chipdriverout 166.7e-3
rj1345 n1811__chipdriverout n1812__chipdriverout 166.7e-3
rj1346 n1813__chipdriverout n1814__chipdriverout 166.7e-3
rj1347 n1815__chipdriverout n1816__chipdriverout 166.7e-3
rj1348 n1838__chipdriverout n1824__chipdriverout 166.7e-3
rj1349 n1827__chipdriverout n1839__chipdriverout 166.7e-3
rj1350 n1840__chipdriverout n1828__chipdriverout 166.7e-3
rj1351 n1830__chipdriverout n1841__chipdriverout 166.7e-3
rj1352 n1842__chipdriverout n1831__chipdriverout 166.7e-3
rj1353 n1833__chipdriverout n1843__chipdriverout 166.7e-3
rj1354 n1844__chipdriverout n1834__chipdriverout 166.7e-3
rj1355 n1836__chipdriverout n1845__chipdriverout 166.7e-3
rj1356 n759__i0__i14__net1 n757__i0__i14__net1 125e-3
rj1357 n758__i0__i14__net1 n759__i0__i14__net1 125e-3
rj1358 n6__i1__net6 n2__i1__net6 1.0038
rj1359 n654__vss n655__vss 166.7e-3
rj1360 n656__vss n657__vss 166.7e-3
rj1361 n658__vss n659__vss 166.7e-3
rj1362 n660__vss n661__vss 166.7e-3
rj1363 n967__vddio n968__vddio 166.7e-3
rj1364 n969__vddio n970__vddio 166.7e-3
rj1365 n971__vddio n972__vddio 166.7e-3
rj1366 n973__vddio n974__vddio 166.7e-3
rj1367 n975__vddio n976__vddio 166.7e-3
rj1368 n977__vddio n978__vddio 166.7e-3
rj1369 n979__vddio n980__vddio 166.7e-3
rj1370 n761__i0__i14__net1 n690__i0__i14__net1 250e-3
rj1371 n692__i0__i14__net1 n761__i0__i14__net1 250e-3
rj1372 n1872__chipdriverout n1864__chipdriverout 166.7e-3
rj1373 n1865__chipdriverout n1873__chipdriverout 166.7e-3
rj1374 n1874__chipdriverout n1867__chipdriverout 166.7e-3
rj1375 n1868__chipdriverout n1875__chipdriverout 166.7e-3
rj1376 n1876__chipdriverout n1870__chipdriverout 166.7e-3
rj1377 n1847__chipdriverout n1877__chipdriverout 166.7e-3
rj1378 n1878__chipdriverout n1850__chipdriverout 166.7e-3
rj1379 n1851__chipdriverout n1879__chipdriverout 166.7e-3
rj1380 n1880__chipdriverout n1853__chipdriverout 166.7e-3
rj1381 n1854__chipdriverout n1881__chipdriverout 166.7e-3
rj1382 n1882__chipdriverout n1856__chipdriverout 166.7e-3
rj1383 n1857__chipdriverout n1883__chipdriverout 166.7e-3
rj1384 n1884__chipdriverout n1859__chipdriverout 166.7e-3
rj1385 n765__i0__i14__net1 n702__i0__i14__net1 250e-3
rj1386 n704__i0__i14__net1 n765__i0__i14__net1 250e-3
rj1387 n9__i1__net6 n7__i1__net6 563.7e-3
rj1388 n673__vss n676__vss 166.7e-3
rj1389 n677__vss n672__vss 166.7e-3
rj1390 n670__vss n678__vss 166.7e-3
rj1391 n679__vss n669__vss 166.7e-3
rj1392 n989__vddio n1002__vddio 166.7e-3
rj1393 n1003__vddio n992__vddio 166.7e-3
rj1394 n993__vddio n1004__vddio 166.7e-3
rj1395 n1005__vddio n995__vddio 166.7e-3
rj1396 n996__vddio n1006__vddio 166.7e-3
rj1397 n1007__vddio n998__vddio 166.7e-3
rj1398 n999__vddio n1008__vddio 166.7e-3
rj1399 n42__s n37__s 1.0568
rj1400 n37__s n40__s 500e-3
rj1401 n771__i0__i14__net1 n769__i0__i14__net1 125e-3
rj1402 n770__i0__i14__net1 n771__i0__i14__net1 125e-3
rj1403 n1903__chipdriverout n1911__chipdriverout 166.7e-3
rj1404 n1912__chipdriverout n1904__chipdriverout 166.7e-3
rj1405 n1906__chipdriverout n1913__chipdriverout 166.7e-3
rj1406 n1914__chipdriverout n1907__chipdriverout 166.7e-3
rj1407 n1909__chipdriverout n1915__chipdriverout 166.7e-3
rj1408 n1916__chipdriverout n1886__chipdriverout 166.7e-3
rj1409 n1889__chipdriverout n1917__chipdriverout 166.7e-3
rj1410 n1918__chipdriverout n1890__chipdriverout 166.7e-3
rj1411 n1892__chipdriverout n1919__chipdriverout 166.7e-3
rj1412 n1920__chipdriverout n1893__chipdriverout 166.7e-3
rj1413 n1895__chipdriverout n1921__chipdriverout 166.7e-3
rj1414 n1922__chipdriverout n1896__chipdriverout 166.7e-3
rj1415 n1898__chipdriverout n1923__chipdriverout 166.7e-3
rj1416 n714__i0__i14__net1 n774__i0__i14__net1 250e-3
rj1417 n774__i0__i14__net1 n716__i0__i14__net1 250e-3
rj1418 n2__r0 n4__r0 1
rj1419 n686__vss n689__vss 166.7e-3
rj1420 n690__vss n685__vss 166.7e-3
rj1421 n683__vss n691__vss 166.7e-3
rj1422 n692__vss n682__vss 166.7e-3
rj1423 n1010__vddio n1023__vddio 166.7e-3
rj1424 n1024__vddio n1013__vddio 166.7e-3
rj1425 n1014__vddio n1025__vddio 166.7e-3
rj1426 n1026__vddio n1016__vddio 166.7e-3
rj1427 n1017__vddio n1027__vddio 166.7e-3
rj1428 n1028__vddio n1019__vddio 166.7e-3
rj1429 n1020__vddio n1029__vddio 166.7e-3
rj1430 n12__i1__net7 n6__i1__net7 1.0508
rj1431 n15__i1__net7 n14__i1__net7 1.0019
rj1432 n748__vss n751__vss 166.7e-3
rj1433 n752__vss n747__vss 166.7e-3
rj1434 n745__vss n753__vss 166.7e-3
rj1435 n754__vss n744__vss 166.7e-3
rj1436 n1080__vddio n1093__vddio 166.7e-3
rj1437 n1094__vddio n1083__vddio 166.7e-3
rj1438 n1084__vddio n1095__vddio 166.7e-3
rj1439 n1096__vddio n1086__vddio 166.7e-3
rj1440 n1087__vddio n1097__vddio 166.7e-3
rj1441 n1098__vddio n1089__vddio 166.7e-3
rj1442 n1090__vddio n1099__vddio 166.7e-3
rj1443 n41__clk n38__clk 1.6189
rj1445 n26__i1__net1 n23__i1__net1 2.0652
rj1447 n63__i0__net2 n61__i0__net2 125e-3
rj1448 n62__i0__net2 n63__i0__net2 125e-3
rj1449 n781__i0__i14__net1 n804__i0__i14__net1 166.7e-3
rj1450 n805__i0__i14__net1 n782__i0__i14__net1 166.7e-3
rj1451 n784__i0__i14__net1 n806__i0__i14__net1 166.7e-3
rj1452 n807__i0__i14__net1 n785__i0__i14__net1 166.7e-3
rj1453 n787__i0__i14__net1 n808__i0__i14__net1 166.7e-3
rj1454 n809__i0__i14__net1 n790__i0__i14__net1 166.7e-3
rj1455 n793__i0__i14__net1 n810__i0__i14__net1 166.7e-3
rj1456 n811__i0__i14__net1 n794__i0__i14__net1 166.7e-3
rj1457 n796__i0__i14__net1 n812__i0__i14__net1 166.7e-3
rj1458 n813__i0__i14__net1 n797__i0__i14__net1 166.7e-3
rj1459 n799__i0__i14__net1 n814__i0__i14__net1 166.7e-3
rj1460 n815__i0__i14__net1 n800__i0__i14__net1 166.7e-3
rj1461 n802__i0__i14__net1 n816__i0__i14__net1 166.7e-3
rj1462 n65__i0__net2 n67__i0__net2 125e-3
rj1463 n67__i0__net2 n66__i0__net2 125e-3
rj1464 n14__reset n13__reset 597.4e-3
rj1465 n761__vss n764__vss 166.7e-3
rj1466 n765__vss n760__vss 166.7e-3
rj1467 n758__vss n766__vss 166.7e-3
rj1468 n767__vss n757__vss 166.7e-3
rj1469 n1101__vddio n1114__vddio 166.7e-3
rj1470 n1115__vddio n1104__vddio 166.7e-3
rj1471 n1105__vddio n1116__vddio 166.7e-3
rj1472 n1117__vddio n1107__vddio 166.7e-3
rj1473 n1108__vddio n1118__vddio 166.7e-3
rj1474 n1119__vddio n1110__vddio 166.7e-3
rj1475 n1111__vddio n1120__vddio 166.7e-3
rj1476 n77__i0__net2 n79__i0__net2 125e-3
rj1477 n79__i0__net2 n78__i0__net2 125e-3
rj1478 n19__pinin n15__pinin 1
rj1479 n820__i0__i14__net1 n843__i0__i14__net1 166.7e-3
rj1480 n844__i0__i14__net1 n821__i0__i14__net1 166.7e-3
rj1481 n823__i0__i14__net1 n845__i0__i14__net1 166.7e-3
rj1482 n846__i0__i14__net1 n824__i0__i14__net1 166.7e-3
rj1483 n826__i0__i14__net1 n847__i0__i14__net1 166.7e-3
rj1484 n848__i0__i14__net1 n829__i0__i14__net1 166.7e-3
rj1485 n832__i0__i14__net1 n849__i0__i14__net1 166.7e-3
rj1486 n850__i0__i14__net1 n833__i0__i14__net1 166.7e-3
rj1487 n835__i0__i14__net1 n851__i0__i14__net1 166.7e-3
rj1488 n852__i0__i14__net1 n836__i0__i14__net1 166.7e-3
rj1489 n838__i0__i14__net1 n853__i0__i14__net1 166.7e-3
rj1490 n854__i0__i14__net1 n839__i0__i14__net1 166.7e-3
rj1491 n841__i0__i14__net1 n855__i0__i14__net1 166.7e-3
rj1492 n81__i0__net2 n83__i0__net2 125e-3
rj1493 n83__i0__net2 n82__i0__net2 125e-3
rj1494 n22__pinin n21__pinin 125e-3
rj1495 n777__vss n774__vss 166.7e-3
rj1496 n773__vss n778__vss 166.7e-3
rj1497 n779__vss n771__vss 166.7e-3
rj1498 n770__vss n780__vss 166.7e-3
rj1499 n1135__vddio n1122__vddio 166.7e-3
rj1500 n1125__vddio n1136__vddio 166.7e-3
rj1501 n1137__vddio n1126__vddio 166.7e-3
rj1502 n1128__vddio n1138__vddio 166.7e-3
rj1503 n1139__vddio n1129__vddio 166.7e-3
rj1504 n1131__vddio n1140__vddio 166.7e-3
rj1505 n1141__vddio n1132__vddio 166.7e-3
rj1506 n18__i0__net2 n90__i0__net2 250e-3
rj1507 n90__i0__net2 n20__i0__net2 250e-3
rj1508 n882__i0__i14__net1 n859__i0__i14__net1 166.7e-3
rj1509 n860__i0__i14__net1 n883__i0__i14__net1 166.7e-3
rj1510 n884__i0__i14__net1 n862__i0__i14__net1 166.7e-3
rj1511 n863__i0__i14__net1 n885__i0__i14__net1 166.7e-3
rj1512 n886__i0__i14__net1 n865__i0__i14__net1 166.7e-3
rj1513 n868__i0__i14__net1 n887__i0__i14__net1 166.7e-3
rj1514 n888__i0__i14__net1 n871__i0__i14__net1 166.7e-3
rj1515 n872__i0__i14__net1 n889__i0__i14__net1 166.7e-3
rj1516 n890__i0__i14__net1 n874__i0__i14__net1 166.7e-3
rj1517 n875__i0__i14__net1 n891__i0__i14__net1 166.7e-3
rj1518 n892__i0__i14__net1 n877__i0__i14__net1 166.7e-3
rj1519 n878__i0__i14__net1 n893__i0__i14__net1 166.7e-3
rj1520 n894__i0__i14__net1 n880__i0__i14__net1 166.7e-3
rj1521 n99__i0__net2 n97__i0__net2 125e-3
rj1522 n98__i0__net2 n99__i0__net2 125e-3
rj1523 n2__pinout n7__pinout 250e-3
rj1524 n825__vss n828__vss 166.7e-3
rj1525 n829__vss n824__vss 166.7e-3
rj1526 n822__vss n830__vss 166.7e-3
rj1527 n831__vss n821__vss 166.7e-3
rj1528 n1143__vddio n1156__vddio 166.7e-3
rj1529 n1157__vddio n1146__vddio 166.7e-3
rj1530 n1147__vddio n1158__vddio 166.7e-3
rj1531 n1159__vddio n1149__vddio 166.7e-3
rj1532 n1150__vddio n1160__vddio 166.7e-3
rj1533 n1161__vddio n1152__vddio 166.7e-3
rj1534 n1153__vddio n1162__vddio 166.7e-3
rj1535 n111__i0__net2 n109__i0__net2 125e-3
rj1536 n110__i0__net2 n111__i0__net2 125e-3
rj1537 n898__i0__i14__net1 n921__i0__i14__net1 166.7e-3
rj1538 n922__i0__i14__net1 n899__i0__i14__net1 166.7e-3
rj1539 n901__i0__i14__net1 n923__i0__i14__net1 166.7e-3
rj1540 n924__i0__i14__net1 n902__i0__i14__net1 166.7e-3
rj1541 n904__i0__i14__net1 n925__i0__i14__net1 166.7e-3
rj1542 n926__i0__i14__net1 n907__i0__i14__net1 166.7e-3
rj1543 n910__i0__i14__net1 n927__i0__i14__net1 166.7e-3
rj1544 n928__i0__i14__net1 n911__i0__i14__net1 166.7e-3
rj1545 n913__i0__i14__net1 n929__i0__i14__net1 166.7e-3
rj1546 n930__i0__i14__net1 n914__i0__i14__net1 166.7e-3
rj1547 n916__i0__i14__net1 n931__i0__i14__net1 166.7e-3
rj1548 n932__i0__i14__net1 n917__i0__i14__net1 166.7e-3
rj1549 n919__i0__i14__net1 n933__i0__i14__net1 166.7e-3
rj1550 n113__i0__net2 n115__i0__net2 125e-3
rj1551 n115__i0__net2 n114__i0__net2 125e-3
rj1552 n838__vss n841__vss 166.7e-3
rj1553 n842__vss n837__vss 166.7e-3
rj1554 n835__vss n843__vss 166.7e-3
rj1555 n844__vss n834__vss 166.7e-3
rj1556 n1164__vddio n1177__vddio 166.7e-3
rj1557 n1178__vddio n1167__vddio 166.7e-3
rj1558 n1168__vddio n1179__vddio 166.7e-3
rj1559 n1180__vddio n1170__vddio 166.7e-3
rj1560 n1171__vddio n1181__vddio 166.7e-3
rj1561 n1182__vddio n1173__vddio 166.7e-3
rj1562 n1174__vddio n1183__vddio 166.7e-3
rj1563 n127__i0__net2 n125__i0__net2 125e-3
rj1564 n126__i0__net2 n127__i0__net2 125e-3
rj1565 n937__i0__i14__net1 n960__i0__i14__net1 166.7e-3
rj1566 n961__i0__i14__net1 n938__i0__i14__net1 166.7e-3
rj1567 n940__i0__i14__net1 n962__i0__i14__net1 166.7e-3
rj1568 n963__i0__i14__net1 n941__i0__i14__net1 166.7e-3
rj1569 n943__i0__i14__net1 n964__i0__i14__net1 166.7e-3
rj1570 n965__i0__i14__net1 n946__i0__i14__net1 166.7e-3
rj1571 n949__i0__i14__net1 n966__i0__i14__net1 166.7e-3
rj1572 n967__i0__i14__net1 n950__i0__i14__net1 166.7e-3
rj1573 n952__i0__i14__net1 n968__i0__i14__net1 166.7e-3
rj1574 n969__i0__i14__net1 n953__i0__i14__net1 166.7e-3
rj1575 n955__i0__i14__net1 n970__i0__i14__net1 166.7e-3
rj1576 n971__i0__i14__net1 n956__i0__i14__net1 166.7e-3
rj1577 n958__i0__i14__net1 n972__i0__i14__net1 166.7e-3
rj1578 n129__i0__net2 n131__i0__net2 125e-3
rj1579 n131__i0__net2 n130__i0__net2 125e-3
rj1580 n851__vss n854__vss 166.7e-3
rj1581 n855__vss n850__vss 166.7e-3
rj1582 n848__vss n856__vss 166.7e-3
rj1583 n857__vss n847__vss 166.7e-3
rj1584 n1185__vddio n1198__vddio 166.7e-3
rj1585 n1199__vddio n1188__vddio 166.7e-3
rj1586 n1189__vddio n1200__vddio 166.7e-3
rj1587 n1201__vddio n1191__vddio 166.7e-3
rj1588 n1192__vddio n1202__vddio 166.7e-3
rj1589 n1203__vddio n1194__vddio 166.7e-3
rj1590 n1195__vddio n1204__vddio 166.7e-3
rj1591 n143__i0__net2 n141__i0__net2 125e-3
rj1592 n142__i0__net2 n143__i0__net2 125e-3
rj1593 n976__i0__i14__net1 n999__i0__i14__net1 166.7e-3
rj1594 n1000__i0__i14__net1 n977__i0__i14__net1 166.7e-3
rj1595 n979__i0__i14__net1 n1001__i0__i14__net1 166.7e-3
rj1596 n1002__i0__i14__net1 n980__i0__i14__net1 166.7e-3
rj1597 n982__i0__i14__net1 n1003__i0__i14__net1 166.7e-3
rj1598 n1004__i0__i14__net1 n985__i0__i14__net1 166.7e-3
rj1599 n988__i0__i14__net1 n1005__i0__i14__net1 166.7e-3
rj1600 n1006__i0__i14__net1 n989__i0__i14__net1 166.7e-3
rj1601 n991__i0__i14__net1 n1007__i0__i14__net1 166.7e-3
rj1602 n1008__i0__i14__net1 n992__i0__i14__net1 166.7e-3
rj1603 n994__i0__i14__net1 n1009__i0__i14__net1 166.7e-3
rj1604 n1010__i0__i14__net1 n995__i0__i14__net1 166.7e-3
rj1605 n997__i0__i14__net1 n1011__i0__i14__net1 166.7e-3
rj1606 n145__i0__net2 n147__i0__net2 125e-3
rj1607 n147__i0__net2 n146__i0__net2 125e-3
rj1608 n864__vss n867__vss 166.7e-3
rj1609 n868__vss n863__vss 166.7e-3
rj1610 n861__vss n869__vss 166.7e-3
rj1611 n870__vss n860__vss 166.7e-3
rj1612 n1206__vddio n1219__vddio 166.7e-3
rj1613 n1220__vddio n1209__vddio 166.7e-3
rj1614 n1210__vddio n1221__vddio 166.7e-3
rj1615 n1222__vddio n1212__vddio 166.7e-3
rj1616 n1213__vddio n1223__vddio 166.7e-3
rj1617 n1224__vddio n1215__vddio 166.7e-3
rj1618 n1216__vddio n1225__vddio 166.7e-3
rj1619 n159__i0__net2 n157__i0__net2 125e-3
rj1620 n158__i0__net2 n159__i0__net2 125e-3
rj1621 n1030__i0__i14__net1 n1038__i0__i14__net1 166.7e-3
rj1622 n1039__i0__i14__net1 n1031__i0__i14__net1 166.7e-3
rj1623 n1033__i0__i14__net1 n1040__i0__i14__net1 166.7e-3
rj1624 n1041__i0__i14__net1 n1034__i0__i14__net1 166.7e-3
rj1625 n1036__i0__i14__net1 n1042__i0__i14__net1 166.7e-3
rj1626 n1043__i0__i14__net1 n1013__i0__i14__net1 166.7e-3
rj1627 n1016__i0__i14__net1 n1044__i0__i14__net1 166.7e-3
rj1628 n1045__i0__i14__net1 n1017__i0__i14__net1 166.7e-3
rj1629 n1019__i0__i14__net1 n1046__i0__i14__net1 166.7e-3
rj1630 n1047__i0__i14__net1 n1020__i0__i14__net1 166.7e-3
rj1631 n1022__i0__i14__net1 n1048__i0__i14__net1 166.7e-3
rj1632 n1049__i0__i14__net1 n1023__i0__i14__net1 166.7e-3
rj1633 n1025__i0__i14__net1 n1050__i0__i14__net1 166.7e-3
rj1634 n54__i0__net2 n162__i0__net2 250e-3
rj1635 n162__i0__net2 n56__i0__net2 250e-3
rj1636 n871__vss n872__vss 166.7e-3
rj1637 n873__vss n874__vss 166.7e-3
rj1638 n875__vss n876__vss 166.7e-3
rj1639 n877__vss n878__vss 166.7e-3
rj1640 n1226__vddio n1227__vddio 166.7e-3
rj1641 n1228__vddio n1229__vddio 166.7e-3
rj1642 n1230__vddio n1231__vddio 166.7e-3
rj1643 n1232__vddio n1233__vddio 166.7e-3
rj1644 n1234__vddio n1235__vddio 166.7e-3
rj1645 n1236__vddio n1237__vddio 166.7e-3
rj1646 n1238__vddio n1239__vddio 166.7e-3
rj1647 n169__i0__net2 n165__i0__net2 125e-3
rj1648 n166__i0__net2 n169__i0__net2 125e-3
rj1649 n1069__i0__i14__net1 n1077__i0__i14__net1 166.7e-3
rj1650 n1078__i0__i14__net1 n1070__i0__i14__net1 166.7e-3
rj1651 n1072__i0__i14__net1 n1079__i0__i14__net1 166.7e-3
rj1652 n1080__i0__i14__net1 n1073__i0__i14__net1 166.7e-3
rj1653 n1075__i0__i14__net1 n1081__i0__i14__net1 166.7e-3
rj1654 n1082__i0__i14__net1 n1052__i0__i14__net1 166.7e-3
rj1655 n1055__i0__i14__net1 n1083__i0__i14__net1 166.7e-3
rj1656 n1084__i0__i14__net1 n1056__i0__i14__net1 166.7e-3
rj1657 n1058__i0__i14__net1 n1085__i0__i14__net1 166.7e-3
rj1658 n1086__i0__i14__net1 n1059__i0__i14__net1 166.7e-3
rj1659 n1061__i0__i14__net1 n1087__i0__i14__net1 166.7e-3
rj1660 n1088__i0__i14__net1 n1062__i0__i14__net1 166.7e-3
rj1661 n1064__i0__i14__net1 n1089__i0__i14__net1 166.7e-3
rj1662 n167__i0__net2 n171__i0__net2 125e-3
rj1663 n171__i0__net2 n168__i0__net2 125e-3
rj1664 n890__vss n893__vss 166.7e-3
rj1665 n894__vss n889__vss 166.7e-3
rj1666 n887__vss n895__vss 166.7e-3
rj1667 n896__vss n886__vss 166.7e-3
rj1668 n1248__vddio n1261__vddio 166.7e-3
rj1669 n1262__vddio n1251__vddio 166.7e-3
rj1670 n1252__vddio n1263__vddio 166.7e-3
rj1671 n1264__vddio n1254__vddio 166.7e-3
rj1672 n1255__vddio n1265__vddio 166.7e-3
rj1673 n1266__vddio n1257__vddio 166.7e-3
rj1674 n1258__vddio n1267__vddio 166.7e-3
rj1675 n175__i0__net2 n173__i0__net2 125e-3
rj1676 n174__i0__net2 n175__i0__net2 125e-3
rj1677 n1093__i0__i14__net1 n1116__i0__i14__net1 166.7e-3
rj1678 n1117__i0__i14__net1 n1094__i0__i14__net1 166.7e-3
rj1679 n1096__i0__i14__net1 n1118__i0__i14__net1 166.7e-3
rj1680 n1119__i0__i14__net1 n1097__i0__i14__net1 166.7e-3
rj1681 n1099__i0__i14__net1 n1120__i0__i14__net1 166.7e-3
rj1682 n1121__i0__i14__net1 n1102__i0__i14__net1 166.7e-3
rj1683 n1105__i0__i14__net1 n1122__i0__i14__net1 166.7e-3
rj1684 n1123__i0__i14__net1 n1106__i0__i14__net1 166.7e-3
rj1685 n1108__i0__i14__net1 n1124__i0__i14__net1 166.7e-3
rj1686 n1125__i0__i14__net1 n1109__i0__i14__net1 166.7e-3
rj1687 n1111__i0__i14__net1 n1126__i0__i14__net1 166.7e-3
rj1688 n1127__i0__i14__net1 n1112__i0__i14__net1 166.7e-3
rj1689 n1114__i0__i14__net1 n1128__i0__i14__net1 166.7e-3
rj1690 n181__i0__net2 n183__i0__net2 125e-3
rj1691 n183__i0__net2 n182__i0__net2 125e-3
rj1692 n903__vss n906__vss 166.7e-3
rj1693 n907__vss n902__vss 166.7e-3
rj1694 n900__vss n908__vss 166.7e-3
rj1695 n909__vss n899__vss 166.7e-3
rj1696 n1269__vddio n1282__vddio 166.7e-3
rj1697 n1283__vddio n1272__vddio 166.7e-3
rj1698 n1273__vddio n1284__vddio 166.7e-3
rj1699 n1285__vddio n1275__vddio 166.7e-3
rj1700 n1276__vddio n1286__vddio 166.7e-3
rj1701 n1287__vddio n1278__vddio 166.7e-3
rj1702 n1279__vddio n1288__vddio 166.7e-3
rj1703 n187__i0__net2 n185__i0__net2 125e-3
rj1704 n186__i0__net2 n187__i0__net2 125e-3
rj1705 n1132__i0__i14__net1 n1155__i0__i14__net1 166.7e-3
rj1706 n1156__i0__i14__net1 n1133__i0__i14__net1 166.7e-3
rj1707 n1135__i0__i14__net1 n1157__i0__i14__net1 166.7e-3
rj1708 n1158__i0__i14__net1 n1136__i0__i14__net1 166.7e-3
rj1709 n1138__i0__i14__net1 n1159__i0__i14__net1 166.7e-3
rj1710 n1160__i0__i14__net1 n1141__i0__i14__net1 166.7e-3
rj1711 n1144__i0__i14__net1 n1161__i0__i14__net1 166.7e-3
rj1712 n1162__i0__i14__net1 n1145__i0__i14__net1 166.7e-3
rj1713 n1147__i0__i14__net1 n1163__i0__i14__net1 166.7e-3
rj1714 n1164__i0__i14__net1 n1148__i0__i14__net1 166.7e-3
rj1715 n1150__i0__i14__net1 n1165__i0__i14__net1 166.7e-3
rj1716 n1166__i0__i14__net1 n1151__i0__i14__net1 166.7e-3
rj1717 n1153__i0__i14__net1 n1167__i0__i14__net1 166.7e-3
rj1718 n189__i0__net2 n191__i0__net2 125e-3
rj1719 n191__i0__net2 n190__i0__net2 125e-3
rj1720 n916__vss n919__vss 166.7e-3
rj1721 n920__vss n915__vss 166.7e-3
rj1722 n913__vss n921__vss 166.7e-3
rj1723 n922__vss n912__vss 166.7e-3
rj1724 n1290__vddio n1303__vddio 166.7e-3
rj1725 n1304__vddio n1293__vddio 166.7e-3
rj1726 n1294__vddio n1305__vddio 166.7e-3
rj1727 n1306__vddio n1296__vddio 166.7e-3
rj1728 n1297__vddio n1307__vddio 166.7e-3
rj1729 n1308__vddio n1299__vddio 166.7e-3
rj1730 n1300__vddio n1309__vddio 166.7e-3
rj1731 n195__i0__net2 n193__i0__net2 125e-3
rj1732 n194__i0__net2 n195__i0__net2 125e-3
rj1733 n1186__i0__i14__net1 n1194__i0__i14__net1 166.7e-3
rj1734 n1195__i0__i14__net1 n1187__i0__i14__net1 166.7e-3
rj1735 n1189__i0__i14__net1 n1196__i0__i14__net1 166.7e-3
rj1736 n1197__i0__i14__net1 n1190__i0__i14__net1 166.7e-3
rj1737 n1192__i0__i14__net1 n1198__i0__i14__net1 166.7e-3
rj1738 n1199__i0__i14__net1 n1169__i0__i14__net1 166.7e-3
rj1739 n1172__i0__i14__net1 n1200__i0__i14__net1 166.7e-3
rj1740 n1201__i0__i14__net1 n1173__i0__i14__net1 166.7e-3
rj1741 n1175__i0__i14__net1 n1202__i0__i14__net1 166.7e-3
rj1742 n1203__i0__i14__net1 n1176__i0__i14__net1 166.7e-3
rj1743 n1178__i0__i14__net1 n1204__i0__i14__net1 166.7e-3
rj1744 n1205__i0__i14__net1 n1179__i0__i14__net1 166.7e-3
rj1745 n1181__i0__i14__net1 n1206__i0__i14__net1 166.7e-3
rj1746 n118__i0__net2 n198__i0__net2 250e-3
rj1747 n198__i0__net2 n120__i0__net2 250e-3
rj1748 n929__vss n932__vss 166.7e-3
rj1749 n933__vss n928__vss 166.7e-3
rj1750 n926__vss n934__vss 166.7e-3
rj1751 n935__vss n925__vss 166.7e-3
rj1752 n1311__vddio n1324__vddio 166.7e-3
rj1753 n1325__vddio n1314__vddio 166.7e-3
rj1754 n1315__vddio n1326__vddio 166.7e-3
rj1755 n1327__vddio n1317__vddio 166.7e-3
rj1756 n1318__vddio n1328__vddio 166.7e-3
rj1757 n1329__vddio n1320__vddio 166.7e-3
rj1758 n1321__vddio n1330__vddio 166.7e-3
rj1759 n203__i0__net2 n201__i0__net2 125e-3
rj1760 n202__i0__net2 n203__i0__net2 125e-3
rj1761 n1225__i0__i14__net1 n1233__i0__i14__net1 166.7e-3
rj1762 n1234__i0__i14__net1 n1226__i0__i14__net1 166.7e-3
rj1763 n1228__i0__i14__net1 n1235__i0__i14__net1 166.7e-3
rj1764 n1236__i0__i14__net1 n1229__i0__i14__net1 166.7e-3
rj1765 n1231__i0__i14__net1 n1237__i0__i14__net1 166.7e-3
rj1766 n1238__i0__i14__net1 n1208__i0__i14__net1 166.7e-3
rj1767 n1211__i0__i14__net1 n1239__i0__i14__net1 166.7e-3
rj1768 n1240__i0__i14__net1 n1212__i0__i14__net1 166.7e-3
rj1769 n1214__i0__i14__net1 n1241__i0__i14__net1 166.7e-3
rj1770 n1242__i0__i14__net1 n1215__i0__i14__net1 166.7e-3
rj1771 n1217__i0__i14__net1 n1243__i0__i14__net1 166.7e-3
rj1772 n1244__i0__i14__net1 n1218__i0__i14__net1 166.7e-3
rj1773 n1220__i0__i14__net1 n1245__i0__i14__net1 166.7e-3
rj1774 n205__i0__net2 n207__i0__net2 125e-3
rj1775 n207__i0__net2 n206__i0__net2 125e-3
rj1776 n942__vss n945__vss 166.7e-3
rj1777 n946__vss n941__vss 166.7e-3
rj1778 n939__vss n947__vss 166.7e-3
rj1779 n948__vss n938__vss 166.7e-3
rj1780 n1332__vddio n1345__vddio 166.7e-3
rj1781 n1346__vddio n1335__vddio 166.7e-3
rj1782 n1336__vddio n1347__vddio 166.7e-3
rj1783 n1348__vddio n1338__vddio 166.7e-3
rj1784 n1339__vddio n1349__vddio 166.7e-3
rj1785 n1350__vddio n1341__vddio 166.7e-3
rj1786 n1342__vddio n1351__vddio 166.7e-3
rj1787 n211__i0__net2 n209__i0__net2 125e-3
rj1788 n210__i0__net2 n211__i0__net2 125e-3
rj1789 n1249__i0__i14__net1 n1272__i0__i14__net1 166.7e-3
rj1790 n1273__i0__i14__net1 n1250__i0__i14__net1 166.7e-3
rj1791 n1252__i0__i14__net1 n1274__i0__i14__net1 166.7e-3
rj1792 n1275__i0__i14__net1 n1253__i0__i14__net1 166.7e-3
rj1793 n1255__i0__i14__net1 n1276__i0__i14__net1 166.7e-3
rj1794 n1277__i0__i14__net1 n1258__i0__i14__net1 166.7e-3
rj1795 n1261__i0__i14__net1 n1278__i0__i14__net1 166.7e-3
rj1796 n1279__i0__i14__net1 n1262__i0__i14__net1 166.7e-3
rj1797 n1264__i0__i14__net1 n1280__i0__i14__net1 166.7e-3
rj1798 n1281__i0__i14__net1 n1265__i0__i14__net1 166.7e-3
rj1799 n1267__i0__i14__net1 n1282__i0__i14__net1 166.7e-3
rj1800 n1283__i0__i14__net1 n1268__i0__i14__net1 166.7e-3
rj1801 n1270__i0__i14__net1 n1284__i0__i14__net1 166.7e-3
rj1802 n213__i0__net2 n215__i0__net2 125e-3
rj1803 n215__i0__net2 n214__i0__net2 125e-3
rj1804 n955__vss n958__vss 166.7e-3
rj1805 n959__vss n954__vss 166.7e-3
rj1806 n952__vss n960__vss 166.7e-3
rj1807 n961__vss n951__vss 166.7e-3
rj1808 n1353__vddio n1366__vddio 166.7e-3
rj1809 n1367__vddio n1356__vddio 166.7e-3
rj1810 n1357__vddio n1368__vddio 166.7e-3
rj1811 n1369__vddio n1359__vddio 166.7e-3
rj1812 n1360__vddio n1370__vddio 166.7e-3
rj1813 n1371__vddio n1362__vddio 166.7e-3
rj1814 n1363__vddio n1372__vddio 166.7e-3
rj1815 n219__i0__net2 n217__i0__net2 125e-3
rj1816 n218__i0__net2 n219__i0__net2 125e-3
rj1817 n1288__i0__i14__net1 n1311__i0__i14__net1 166.7e-3
rj1818 n1312__i0__i14__net1 n1289__i0__i14__net1 166.7e-3
rj1819 n1291__i0__i14__net1 n1313__i0__i14__net1 166.7e-3
rj1820 n1314__i0__i14__net1 n1292__i0__i14__net1 166.7e-3
rj1821 n1294__i0__i14__net1 n1315__i0__i14__net1 166.7e-3
rj1822 n1316__i0__i14__net1 n1297__i0__i14__net1 166.7e-3
rj1823 n1300__i0__i14__net1 n1317__i0__i14__net1 166.7e-3
rj1824 n1318__i0__i14__net1 n1301__i0__i14__net1 166.7e-3
rj1825 n1303__i0__i14__net1 n1319__i0__i14__net1 166.7e-3
rj1826 n1320__i0__i14__net1 n1304__i0__i14__net1 166.7e-3
rj1827 n1306__i0__i14__net1 n1321__i0__i14__net1 166.7e-3
rj1828 n1322__i0__i14__net1 n1307__i0__i14__net1 166.7e-3
rj1829 n1309__i0__i14__net1 n1323__i0__i14__net1 166.7e-3
rj1830 n178__i0__net2 n222__i0__net2 250e-3
rj1831 n222__i0__net2 n180__i0__net2 250e-3
rj1832 n968__vss n971__vss 166.7e-3
rj1833 n972__vss n967__vss 166.7e-3
rj1834 n965__vss n973__vss 166.7e-3
rj1835 n974__vss n964__vss 166.7e-3
rj1836 n1374__vddio n1387__vddio 166.7e-3
rj1837 n1388__vddio n1377__vddio 166.7e-3
rj1838 n1378__vddio n1389__vddio 166.7e-3
rj1839 n1390__vddio n1380__vddio 166.7e-3
rj1840 n1381__vddio n1391__vddio 166.7e-3
rj1841 n1392__vddio n1383__vddio 166.7e-3
rj1842 n1384__vddio n1393__vddio 166.7e-3
rj1844 n970__vss n1012__vss 131.6e-3
rj1846 n1012__vss n1014__vss 14.77e-3
rj1847 n1014__vss n1015__vss 34.93e-3
rj1848 n1015__vss n1016__vss 51.54e-3
rj1850 n1014__vss n957__vss 106.7e-3
rj1852 n1015__vss n944__vss 106.7e-3
rj1853 n944__vss n1019__vss 83.33e-3
rj1854 n1016__vss n931__vss 112.7e-3
rj1855 n931__vss n1020__vss 83.33e-3
rj1856 n1016__vss n918__vss 112.7e-3
rj1857 n918__vss n1021__vss 83.33e-3
rj1858 n1016__vss n1022__vss 48.6e-3
rj1859 n1022__vss n905__vss 106.7e-3
rj1861 n1022__vss n1024__vss 34.93e-3
rj1862 n1024__vss n892__vss 106.7e-3
rj1863 n892__vss n1025__vss 83.33e-3
rj1864 n1024__vss n1026__vss 52.04e-3
rj1866 n1026__vss n883__vss 112.7e-3
rj1867 n883__vss n1028__vss 83.33e-3
rj1868 n1026__vss n866__vss 112.7e-3
rj1869 n866__vss n1029__vss 83.33e-3
rj1870 n1026__vss n1030__vss 48.11e-3
rj1871 n1030__vss n853__vss 106.7e-3
rj1873 n1030__vss n1032__vss 34.93e-3
rj1874 n1032__vss n840__vss 106.7e-3
rj1875 n840__vss n1033__vss 83.33e-3
rj1876 n1032__vss n1034__vss 52.53e-3
rj1878 n1034__vss n827__vss 112.7e-3
rj1879 n827__vss n1036__vss 83.33e-3
rj1880 n1034__vss n776__vss 112.7e-3
rj1882 n1034__vss n1038__vss 47.62e-3
rj1883 n1038__vss n763__vss 106.7e-3
rj1885 n1038__vss n1040__vss 34.93e-3
rj1886 n1040__vss n750__vss 106.7e-3
rj1887 n750__vss n1041__vss 83.33e-3
rj1888 n1040__vss n1042__vss 53.02e-3
rj1890 n1042__vss n1044__vss 57.92e-3
rj1891 n1044__vss n688__vss 106.7e-3
rj1893 n1044__vss n1045__vss 32.48e-3
rj1894 n1045__vss n675__vss 106.7e-3
rj1895 n675__vss n694__vss 83.33e-3
rj1896 n1045__vss n1046__vss 45.17e-3
rj1898 n1046__vss n666__vss 112.7e-3
rj1899 n666__vss n695__vss 83.33e-3
rj1900 n1046__vss n642__vss 112.7e-3
rj1901 n642__vss n696__vss 83.33e-3
rj1902 n1046__vss n1048__vss 57.43e-3
rj1903 n1048__vss n613__vss 106.7e-3
rj1905 n1048__vss n1050__vss 32.48e-3
rj1906 n1050__vss n570__vss 106.7e-3
rj1907 n570__vss n698__vss 83.33e-3
rj1908 n1050__vss n1051__vss 45.66e-3
rj1910 n1051__vss n557__vss 112.7e-3
rj1911 n557__vss n699__vss 83.33e-3
rj1912 n1051__vss n548__vss 112.7e-3
rj1913 n548__vss n700__vss 83.33e-3
rj1914 n1051__vss n1053__vss 56.94e-3
rj1915 n1053__vss n531__vss 106.7e-3
rj1916 n531__vss n701__vss 83.33e-3
rj1917 n1053__vss n1054__vss 32.48e-3
rj1918 n1054__vss n518__vss 106.7e-3
rj1919 n518__vss n702__vss 83.33e-3
rj1920 n1054__vss n1055__vss 46.15e-3
rj1922 n1055__vss n505__vss 112.7e-3
rj1924 n1055__vss n492__vss 112.7e-3
rj1926 n1055__vss n1059__vss 56.45e-3
rj1927 n1059__vss n479__vss 106.7e-3
rj1928 n479__vss n705__vss 83.33e-3
rj1929 n1059__vss n1060__vss 32.48e-3
rj1930 n1060__vss n466__vss 106.7e-3
rj1931 n466__vss n706__vss 83.33e-3
rj1932 n1060__vss n1061__vss 46.64e-3
rj1934 n1061__vss n453__vss 112.7e-3
rj1935 n453__vss n707__vss 83.33e-3
rj1936 n1061__vss n444__vss 112.7e-3
rj1937 n444__vss n708__vss 83.33e-3
rj1938 n1061__vss n1063__vss 56.94e-3
rj1939 n1063__vss n431__vss 106.7e-3
rj1941 n1063__vss n1065__vss 34.93e-3
rj1942 n1065__vss n416__vss 106.7e-3
rj1943 n416__vss n710__vss 83.33e-3
rj1944 n1065__vss n1066__vss 43.7e-3
rj1946 n1066__vss n399__vss 112.7e-3
rj1948 n1066__vss n390__vss 112.7e-3
rj1950 n1066__vss n1070__vss 56.45e-3
rj1951 n1070__vss n373__vss 106.7e-3
rj1953 n1070__vss n1072__vss 34.93e-3
rj1954 n1072__vss n364__vss 106.7e-3
rj1955 n364__vss n714__vss 83.33e-3
rj1956 n1072__vss n1073__vss 44.19e-3
rj1958 n1073__vss n347__vss 112.7e-3
rj1959 n347__vss n715__vss 83.33e-3
rj1960 n1073__vss n338__vss 112.7e-3
rj1961 n338__vss n716__vss 83.33e-3
rj1962 n1073__vss n1075__vss 55.96e-3
rj1963 n1075__vss n325__vss 106.7e-3
rj1965 n1075__vss n1077__vss 34.93e-3
rj1966 n1077__vss n312__vss 106.7e-3
rj1967 n312__vss n718__vss 83.33e-3
rj1968 n1077__vss n1078__vss 44.68e-3
rj1970 n1078__vss n299__vss 112.7e-3
rj1971 n299__vss n719__vss 83.33e-3
rj1972 n1078__vss n286__vss 112.7e-3
rj1974 n1078__vss n1081__vss 55.47e-3
rj1975 n1081__vss n273__vss 106.7e-3
rj1977 n1081__vss n1083__vss 34.93e-3
rj1978 n1083__vss n260__vss 106.7e-3
rj1979 n260__vss n722__vss 83.33e-3
rj1980 n1083__vss n1084__vss 45.17e-3
rj1982 n1084__vss n243__vss 112.7e-3
rj1983 n243__vss n723__vss 83.33e-3
rj1984 n1084__vss n230__vss 112.7e-3
rj1986 n1084__vss n1087__vss 59.39e-3
rj1987 n1087__vss n217__vss 106.7e-3
rj1989 n1087__vss n1089__vss 32.48e-3
rj1990 n1089__vss n204__vss 106.7e-3
rj1991 n204__vss n726__vss 83.33e-3
rj1992 n1089__vss n1090__vss 43.7e-3
rj1994 n1090__vss n191__vss 112.7e-3
rj1995 n191__vss n727__vss 83.33e-3
rj1996 n1090__vss n178__vss 112.7e-3
rj1997 n178__vss n728__vss 83.33e-3
rj1998 n1090__vss n1092__vss 58.9e-3
rj1999 n1092__vss n165__vss 106.7e-3
rj2001 n1092__vss n1094__vss 32.48e-3
rj2002 n1094__vss n152__vss 106.7e-3
rj2003 n152__vss n730__vss 83.33e-3
rj2004 n1094__vss n1095__vss 44.19e-3
rj2006 n1095__vss n139__vss 112.7e-3
rj2007 n139__vss n731__vss 83.33e-3
rj2008 n1095__vss n126__vss 112.7e-3
rj2010 n1095__vss n1098__vss 58.41e-3
rj2011 n1098__vss n113__vss 106.7e-3
rj2013 n1098__vss n1100__vss 32.48e-3
rj2014 n1100__vss n100__vss 106.7e-3
rj2015 n100__vss n734__vss 83.33e-3
rj2016 n1100__vss n1101__vss 44.68e-3
rj2018 n1101__vss n87__vss 112.7e-3
rj2019 n87__vss n735__vss 83.33e-3
rj2020 n1101__vss n74__vss 112.7e-3
rj2022 n1101__vss n1104__vss 57.92e-3
rj2023 n1104__vss n61__vss 106.7e-3
rj2024 n61__vss n737__vss 83.33e-3
rj2025 n1104__vss n1105__vss 32.97e-3
rj2026 n1105__vss n48__vss 106.7e-3
rj2027 n48__vss n738__vss 83.33e-3
rj2028 n1105__vss n1106__vss 44.68e-3
rj2030 n1106__vss n35__vss 112.7e-3
rj2031 n35__vss n739__vss 83.33e-3
rj2032 n1106__vss n22__vss 112.7e-3
rj2034 n1106__vss n9__vss 171.9e-3
rj2036 n976__vss n1012__vss 8.333e-3
rj2037 n978__vss n1016__vss 4.167e-3
rj2038 n980__vss n1026__vss 4.167e-3
rj2039 n982__vss n1034__vss 4.167e-3
rj2040 n984__vss n1042__vss 4.167e-3
rj2041 n987__vss n1046__vss 4.167e-3
rj2042 n697__vss n613__vss 83.33e-3
rj2043 n989__vss n1051__vss 4.167e-3
rj2044 n991__vss n1055__vss 4.167e-3
rj2045 n703__vss n505__vss 83.33e-3
rj2046 n704__vss n492__vss 83.33e-3
rj2047 n993__vss n1061__vss 4.167e-3
rj2048 n709__vss n431__vss 83.33e-3
rj2049 n995__vss n1066__vss 4.167e-3
rj2050 n711__vss n399__vss 83.33e-3
rj2051 n712__vss n390__vss 83.33e-3
rj2052 n713__vss n373__vss 83.33e-3
rj2053 n997__vss n1073__vss 4.167e-3
rj2054 n717__vss n325__vss 83.33e-3
rj2055 n1000__vss n1078__vss 4.167e-3
rj2056 n720__vss n286__vss 83.33e-3
rj2057 n721__vss n273__vss 83.33e-3
rj2058 n1002__vss n1084__vss 4.167e-3
rj2059 n724__vss n230__vss 83.33e-3
rj2060 n725__vss n217__vss 83.33e-3
rj2061 n1004__vss n1090__vss 4.167e-3
rj2062 n729__vss n165__vss 83.33e-3
rj2063 n1006__vss n1095__vss 4.167e-3
rj2064 n732__vss n126__vss 83.33e-3
rj2065 n733__vss n113__vss 83.33e-3
rj2066 n1008__vss n1101__vss 4.167e-3
rj2067 n736__vss n74__vss 83.33e-3
rj2068 n1010__vss n1106__vss 4.167e-3
rj2069 n740__vss n22__vss 83.33e-3
rj2071 n1386__vddio n1432__vddio 158.5e-3
rj2073 n1432__vddio n1434__vddio 14.77e-3
rj2074 n1434__vddio n1435__vddio 34.93e-3
rj2075 n1435__vddio n1436__vddio 51.54e-3
rj2077 n1434__vddio n1365__vddio 133.6e-3
rj2079 n1435__vddio n1344__vddio 133.6e-3
rj2080 n1344__vddio n1439__vddio 83.33e-3
rj2081 n1436__vddio n1323__vddio 139.6e-3
rj2082 n1323__vddio n1440__vddio 83.33e-3
rj2083 n1436__vddio n1441__vddio 48.6e-3
rj2084 n1441__vddio n1442__vddio 34.93e-3
rj2085 n1442__vddio n1443__vddio 52.04e-3
rj2087 n1443__vddio n1445__vddio 48.11e-3
rj2088 n1445__vddio n1446__vddio 34.93e-3
rj2089 n1446__vddio n1447__vddio 52.53e-3
rj2091 n1447__vddio n1449__vddio 47.62e-3
rj2092 n1449__vddio n1450__vddio 34.93e-3
rj2093 n1450__vddio n1451__vddio 53.02e-3
rj2095 n1451__vddio n1453__vddio 57.92e-3
rj2096 n1453__vddio n1454__vddio 32.48e-3
rj2097 n1454__vddio n1455__vddio 45.17e-3
rj2099 n1455__vddio n1457__vddio 57.43e-3
rj2100 n1457__vddio n1458__vddio 32.48e-3
rj2101 n1458__vddio n1459__vddio 45.66e-3
rj2103 n1459__vddio n1461__vddio 56.94e-3
rj2104 n1461__vddio n1462__vddio 32.48e-3
rj2105 n1462__vddio n1463__vddio 46.15e-3
rj2107 n1463__vddio n1465__vddio 56.45e-3
rj2108 n1465__vddio n1466__vddio 32.48e-3
rj2109 n1466__vddio n1467__vddio 46.64e-3
rj2111 n1467__vddio n1469__vddio 56.94e-3
rj2112 n1469__vddio n1470__vddio 34.93e-3
rj2113 n1470__vddio n1471__vddio 43.7e-3
rj2115 n1471__vddio n1473__vddio 56.45e-3
rj2116 n1473__vddio n1474__vddio 34.93e-3
rj2117 n1474__vddio n1475__vddio 44.19e-3
rj2119 n1475__vddio n1477__vddio 55.96e-3
rj2120 n1477__vddio n1478__vddio 34.93e-3
rj2121 n1478__vddio n1479__vddio 44.68e-3
rj2123 n1479__vddio n1481__vddio 55.47e-3
rj2124 n1481__vddio n1482__vddio 34.93e-3
rj2125 n1482__vddio n1483__vddio 45.17e-3
rj2127 n1483__vddio n1485__vddio 59.39e-3
rj2128 n1485__vddio n1486__vddio 32.48e-3
rj2129 n1486__vddio n1487__vddio 43.7e-3
rj2131 n1487__vddio n1489__vddio 58.9e-3
rj2132 n1489__vddio n1490__vddio 32.48e-3
rj2133 n1490__vddio n1491__vddio 44.19e-3
rj2135 n1491__vddio n1493__vddio 58.41e-3
rj2136 n1493__vddio n1494__vddio 32.48e-3
rj2137 n1494__vddio n1495__vddio 44.68e-3
rj2139 n1495__vddio n1497__vddio 57.92e-3
rj2140 n1497__vddio n1498__vddio 32.97e-3
rj2141 n1498__vddio n1499__vddio 44.68e-3
rj2143 n1499__vddio n14__vddio 198.8e-3
rj2145 n1436__vddio n1302__vddio 139.6e-3
rj2146 n1302__vddio n1501__vddio 83.33e-3
rj2147 n1441__vddio n1281__vddio 133.6e-3
rj2149 n1442__vddio n1260__vddio 133.6e-3
rj2150 n1260__vddio n1503__vddio 83.33e-3
rj2151 n1443__vddio n1246__vddio 139.6e-3
rj2152 n1246__vddio n1504__vddio 83.33e-3
rj2153 n1443__vddio n1218__vddio 139.6e-3
rj2154 n1218__vddio n1505__vddio 83.33e-3
rj2155 n1445__vddio n1197__vddio 133.6e-3
rj2157 n1446__vddio n1176__vddio 133.6e-3
rj2158 n1176__vddio n1507__vddio 83.33e-3
rj2159 n1447__vddio n1155__vddio 139.6e-3
rj2160 n1155__vddio n1508__vddio 83.33e-3
rj2161 n1447__vddio n1134__vddio 139.6e-3
rj2163 n1449__vddio n1113__vddio 133.6e-3
rj2165 n1450__vddio n1092__vddio 133.6e-3
rj2166 n1092__vddio n1511__vddio 83.33e-3
rj2167 n1453__vddio n1022__vddio 133.6e-3
rj2169 n1454__vddio n1001__vddio 133.6e-3
rj2170 n1001__vddio n1031__vddio 83.33e-3
rj2171 n1455__vddio n987__vddio 139.6e-3
rj2173 n1455__vddio n966__vddio 139.6e-3
rj2175 n1457__vddio n938__vddio 133.6e-3
rj2177 n1458__vddio n917__vddio 133.6e-3
rj2178 n917__vddio n1035__vddio 83.33e-3
rj2179 n1459__vddio n896__vddio 139.6e-3
rj2181 n1459__vddio n882__vddio 139.6e-3
rj2183 n1461__vddio n854__vddio 133.6e-3
rj2184 n854__vddio n1038__vddio 83.33e-3
rj2185 n1462__vddio n833__vddio 133.6e-3
rj2186 n833__vddio n1039__vddio 83.33e-3
rj2187 n1463__vddio n812__vddio 139.6e-3
rj2189 n1463__vddio n791__vddio 139.6e-3
rj2191 n1465__vddio n770__vddio 133.6e-3
rj2192 n770__vddio n1042__vddio 83.33e-3
rj2193 n1466__vddio n749__vddio 133.6e-3
rj2194 n749__vddio n1043__vddio 83.33e-3
rj2195 n1467__vddio n728__vddio 139.6e-3
rj2196 n728__vddio n1044__vddio 83.33e-3
rj2197 n1467__vddio n707__vddio 139.6e-3
rj2198 n707__vddio n1045__vddio 83.33e-3
rj2199 n1469__vddio n686__vddio 133.6e-3
rj2201 n1470__vddio n672__vddio 133.6e-3
rj2202 n672__vddio n1047__vddio 83.33e-3
rj2203 n1471__vddio n644__vddio 139.6e-3
rj2205 n1471__vddio n630__vddio 139.6e-3
rj2207 n1473__vddio n602__vddio 133.6e-3
rj2209 n1474__vddio n588__vddio 133.6e-3
rj2210 n588__vddio n1051__vddio 83.33e-3
rj2211 n1475__vddio n560__vddio 139.6e-3
rj2212 n560__vddio n1052__vddio 83.33e-3
rj2213 n1475__vddio n546__vddio 139.6e-3
rj2214 n546__vddio n1053__vddio 83.33e-3
rj2215 n1477__vddio n518__vddio 133.6e-3
rj2217 n1478__vddio n497__vddio 133.6e-3
rj2218 n497__vddio n1055__vddio 83.33e-3
rj2219 n1479__vddio n476__vddio 139.6e-3
rj2220 n476__vddio n1056__vddio 83.33e-3
rj2221 n1479__vddio n455__vddio 139.6e-3
rj2223 n1481__vddio n434__vddio 133.6e-3
rj2225 n1482__vddio n413__vddio 133.6e-3
rj2226 n413__vddio n1059__vddio 83.33e-3
rj2227 n1483__vddio n392__vddio 139.6e-3
rj2228 n392__vddio n1060__vddio 83.33e-3
rj2229 n1483__vddio n371__vddio 139.6e-3
rj2230 n371__vddio n1061__vddio 83.33e-3
rj2231 n1485__vddio n350__vddio 133.6e-3
rj2232 n350__vddio n1062__vddio 83.33e-3
rj2233 n1486__vddio n329__vddio 133.6e-3
rj2235 n1487__vddio n308__vddio 139.6e-3
rj2237 n1487__vddio n287__vddio 139.6e-3
rj2239 n1489__vddio n266__vddio 133.6e-3
rj2240 n266__vddio n1066__vddio 83.33e-3
rj2241 n1490__vddio n245__vddio 133.6e-3
rj2242 n245__vddio n1067__vddio 83.33e-3
rj2243 n1491__vddio n224__vddio 139.6e-3
rj2244 n224__vddio n1068__vddio 83.33e-3
rj2245 n1491__vddio n203__vddio 139.6e-3
rj2247 n1493__vddio n182__vddio 133.6e-3
rj2249 n1494__vddio n161__vddio 133.6e-3
rj2250 n161__vddio n1071__vddio 83.33e-3
rj2251 n1495__vddio n140__vddio 139.6e-3
rj2252 n140__vddio n1072__vddio 83.33e-3
rj2253 n1495__vddio n119__vddio 139.6e-3
rj2255 n1497__vddio n98__vddio 133.6e-3
rj2256 n98__vddio n1074__vddio 83.33e-3
rj2257 n1498__vddio n77__vddio 133.6e-3
rj2258 n77__vddio n1075__vddio 83.33e-3
rj2259 n1499__vddio n56__vddio 139.6e-3
rj2260 n56__vddio n1076__vddio 83.33e-3
rj2261 n1499__vddio n35__vddio 139.6e-3
rj2263 n1396__vddio n1432__vddio 8.333e-3
rj2264 n1398__vddio n1436__vddio 4.167e-3
rj2265 n1400__vddio n1443__vddio 4.167e-3
rj2266 n1402__vddio n1447__vddio 4.167e-3
rj2267 n1404__vddio n1451__vddio 4.167e-3
rj2268 n1407__vddio n1455__vddio 4.167e-3
rj2269 n1409__vddio n1459__vddio 4.167e-3
rj2270 n1411__vddio n1463__vddio 4.167e-3
rj2271 n1413__vddio n1467__vddio 4.167e-3
rj2272 n1415__vddio n1471__vddio 4.167e-3
rj2273 n1417__vddio n1475__vddio 4.167e-3
rj2274 n1420__vddio n1479__vddio 4.167e-3
rj2275 n1422__vddio n1483__vddio 4.167e-3
rj2276 n1424__vddio n1487__vddio 4.167e-3
rj2277 n1426__vddio n1491__vddio 4.167e-3
rj2278 n1428__vddio n1495__vddio 4.167e-3
rj2279 n1430__vddio n1499__vddio 4.167e-3
rj2280 n1032__vddio n987__vddio 83.33e-3
rj2281 n1033__vddio n966__vddio 83.33e-3
rj2282 n1034__vddio n938__vddio 83.33e-3
rj2283 n1036__vddio n896__vddio 83.33e-3
rj2284 n1037__vddio n882__vddio 83.33e-3
rj2285 n1040__vddio n812__vddio 83.33e-3
rj2286 n1041__vddio n791__vddio 83.33e-3
rj2287 n1046__vddio n686__vddio 83.33e-3
rj2288 n1048__vddio n644__vddio 83.33e-3
rj2289 n1049__vddio n630__vddio 83.33e-3
rj2290 n1050__vddio n602__vddio 83.33e-3
rj2291 n1054__vddio n518__vddio 83.33e-3
rj2292 n1057__vddio n455__vddio 83.33e-3
rj2293 n1058__vddio n434__vddio 83.33e-3
rj2294 n1063__vddio n329__vddio 83.33e-3
rj2295 n1064__vddio n308__vddio 83.33e-3
rj2296 n1065__vddio n287__vddio 83.33e-3
rj2297 n1069__vddio n203__vddio 83.33e-3
rj2298 n1070__vddio n182__vddio 83.33e-3
rj2299 n1073__vddio n119__vddio 83.33e-3
rj2300 n1077__vddio n35__vddio 83.33e-3
rj2301 n59__i0__i13__net1 n57__i0__i13__net1 125e-3
rj2302 n58__i0__i13__net1 n60__i0__i13__net1 125e-3
rj2303 n59__i0__i13__net1 n69__i0__i13__net1 125e-3
rj2304 n70__i0__i13__net1 n60__i0__i13__net1 125e-3
rj2305 n75__i0__i13__net1 n73__i0__i13__net1 125e-3
rj2306 n74__i0__i13__net1 n76__i0__i13__net1 125e-3
rj2307 n75__i0__i13__net1 n85__i0__i13__net1 125e-3
rj2308 n86__i0__i13__net1 n76__i0__i13__net1 125e-3
rj2309 n91__i0__i13__net1 n89__i0__i13__net1 125e-3
rj2310 n90__i0__i13__net1 n92__i0__i13__net1 125e-3
rj2311 n97__i0__i13__net1 n91__i0__i13__net1 125e-3
rj2312 n92__i0__i13__net1 n98__i0__i13__net1 125e-3
rj2313 n105__i0__i13__net1 n27__i0__i13__net1 250e-3
rj2314 n26__i0__i13__net1 n108__i0__i13__net1 250e-3
rj2315 n105__i0__i13__net1 n32__i0__i13__net1 250e-3
rj2316 n30__i0__i13__net1 n108__i0__i13__net1 250e-3
rj2317 n115__i0__i13__net1 n113__i0__i13__net1 125e-3
rj2318 n114__i0__i13__net1 n116__i0__i13__net1 125e-3
rj2319 n115__i0__i13__net1 n117__i0__i13__net1 125e-3
rj2320 n118__i0__i13__net1 n116__i0__i13__net1 125e-3
rj2321 n127__i0__i13__net1 n125__i0__i13__net1 125e-3
rj2322 n126__i0__i13__net1 n128__i0__i13__net1 125e-3
rj2323 n129__i0__i13__net1 n127__i0__i13__net1 125e-3
rj2324 n128__i0__i13__net1 n130__i0__i13__net1 125e-3
rj2325 n135__i0__i13__net1 n133__i0__i13__net1 125e-3
rj2326 n134__i0__i13__net1 n136__i0__i13__net1 125e-3
rj2327 n135__i0__i13__net1 n137__i0__i13__net1 125e-3
rj2328 n138__i0__i13__net1 n136__i0__i13__net1 125e-3
rj2329 n143__i0__i13__net1 n141__i0__i13__net1 125e-3
rj2330 n142__i0__i13__net1 n144__i0__i13__net1 125e-3
rj2331 n143__i0__i13__net1 n68__i0__i13__net1 250e-3
rj2332 n66__i0__i13__net1 n144__i0__i13__net1 250e-3
rj2333 n153__i0__i13__net1 n149__i0__i13__net1 125e-3
rj2334 n150__i0__i13__net1 n154__i0__i13__net1 125e-3
rj2335 n153__i0__i13__net1 n151__i0__i13__net1 125e-3
rj2336 n152__i0__i13__net1 n154__i0__i13__net1 125e-3
rj2337 n159__i0__i13__net1 n157__i0__i13__net1 125e-3
rj2338 n158__i0__i13__net1 n160__i0__i13__net1 125e-3
rj2339 n159__i0__i13__net1 n161__i0__i13__net1 125e-3
rj2340 n162__i0__i13__net1 n160__i0__i13__net1 125e-3
rj2341 n225__i0__net2 n330__i0__net2 58.13e-3
rj2342 n330__i0__net2 n331__i0__net2 83.35e-3
rj2343 n331__i0__net2 n332__i0__net2 85.78e-3
rj2344 n332__i0__net2 n333__i0__net2 84.56e-3
rj2345 n333__i0__net2 n334__i0__net2 83.35e-3
rj2346 n334__i0__net2 n335__i0__net2 85.78e-3
rj2347 n335__i0__net2 n336__i0__net2 84.56e-3
rj2348 n336__i0__net2 n337__i0__net2 83.35e-3
rj2349 n337__i0__net2 n338__i0__net2 84.56e-3
rj2350 n338__i0__net2 n339__i0__net2 84.56e-3
rj2351 n339__i0__net2 n322__i0__net2 166.7e-3
rj2352 n237__i0__net2 n330__i0__net2 83.33e-3
rj2353 n241__i0__net2 n331__i0__net2 83.33e-3
rj2354 n255__i0__net2 n332__i0__net2 83.33e-3
rj2355 n264__i0__net2 n333__i0__net2 83.33e-3
rj2356 n273__i0__net2 n334__i0__net2 83.33e-3
rj2357 n282__i0__net2 n335__i0__net2 83.33e-3
rj2358 n291__i0__net2 n336__i0__net2 83.33e-3
rj2359 n300__i0__net2 n337__i0__net2 83.33e-3
rj2360 n309__i0__net2 n338__i0__net2 83.33e-3
rj2361 n313__i0__net2 n339__i0__net2 83.33e-3
rj2362 n226__i0__net2 n239__i0__net2 120.6e-3
rj2363 n239__i0__net2 n243__i0__net2 83.35e-3
rj2364 n243__i0__net2 n257__i0__net2 85.78e-3
rj2365 n257__i0__net2 n266__i0__net2 84.56e-3
rj2366 n266__i0__net2 n275__i0__net2 83.35e-3
rj2367 n275__i0__net2 n284__i0__net2 85.78e-3
rj2368 n284__i0__net2 n293__i0__net2 84.56e-3
rj2369 n293__i0__net2 n302__i0__net2 83.35e-3
rj2370 n302__i0__net2 n311__i0__net2 84.56e-3
rj2371 n311__i0__net2 n315__i0__net2 84.56e-3
rj2372 n315__i0__net2 n324__i0__net2 83.35e-3
rj2373 n228__i0__net2 n340__i0__net2 120.6e-3
rj2374 n340__i0__net2 n341__i0__net2 85.78e-3
rj2375 n341__i0__net2 n342__i0__net2 83.35e-3
rj2376 n342__i0__net2 n343__i0__net2 84.56e-3
rj2377 n343__i0__net2 n344__i0__net2 83.35e-3
rj2378 n344__i0__net2 n345__i0__net2 85.78e-3
rj2379 n345__i0__net2 n346__i0__net2 84.56e-3
rj2380 n346__i0__net2 n347__i0__net2 83.35e-3
rj2381 n347__i0__net2 n348__i0__net2 84.56e-3
rj2382 n348__i0__net2 n349__i0__net2 85.78e-3
rj2383 n349__i0__net2 n325__i0__net2 167.9e-3
rj2384 n231__i0__net2 n340__i0__net2 83.33e-3
rj2385 n244__i0__net2 n341__i0__net2 83.33e-3
rj2386 n249__i0__net2 n342__i0__net2 83.33e-3
rj2387 n258__i0__net2 n343__i0__net2 83.33e-3
rj2388 n267__i0__net2 n344__i0__net2 83.33e-3
rj2389 n276__i0__net2 n345__i0__net2 83.33e-3
rj2390 n285__i0__net2 n346__i0__net2 83.33e-3
rj2391 n294__i0__net2 n347__i0__net2 83.33e-3
rj2392 n303__i0__net2 n348__i0__net2 83.33e-3
rj2393 n316__i0__net2 n349__i0__net2 83.33e-3
rj2394 n229__i0__net2 n350__i0__net2 120.6e-3
rj2395 n350__i0__net2 n351__i0__net2 85.78e-3
rj2396 n351__i0__net2 n352__i0__net2 83.35e-3
rj2397 n352__i0__net2 n353__i0__net2 84.56e-3
rj2398 n353__i0__net2 n354__i0__net2 83.35e-3
rj2399 n354__i0__net2 n355__i0__net2 85.78e-3
rj2400 n355__i0__net2 n356__i0__net2 84.56e-3
rj2401 n356__i0__net2 n357__i0__net2 83.35e-3
rj2402 n357__i0__net2 n358__i0__net2 84.56e-3
rj2403 n358__i0__net2 n359__i0__net2 85.78e-3
rj2404 n359__i0__net2 n326__i0__net2 167.9e-3
rj2405 n232__i0__net2 n350__i0__net2 83.33e-3
rj2406 n245__i0__net2 n351__i0__net2 83.33e-3
rj2407 n250__i0__net2 n352__i0__net2 83.33e-3
rj2408 n259__i0__net2 n353__i0__net2 83.33e-3
rj2409 n268__i0__net2 n354__i0__net2 83.33e-3
rj2410 n277__i0__net2 n355__i0__net2 83.33e-3
rj2411 n286__i0__net2 n356__i0__net2 83.33e-3
rj2412 n295__i0__net2 n357__i0__net2 83.33e-3
rj2413 n304__i0__net2 n358__i0__net2 83.33e-3
rj2414 n317__i0__net2 n359__i0__net2 83.33e-3
rj2415 n230__i0__net2 n235__i0__net2 58.13e-3
rj2416 n235__i0__net2 n248__i0__net2 85.78e-3
rj2417 n248__i0__net2 n253__i0__net2 83.35e-3
rj2418 n253__i0__net2 n262__i0__net2 84.56e-3
rj2419 n262__i0__net2 n271__i0__net2 83.35e-3
rj2420 n271__i0__net2 n280__i0__net2 85.78e-3
rj2421 n280__i0__net2 n289__i0__net2 84.56e-3
rj2422 n289__i0__net2 n298__i0__net2 83.35e-3
rj2423 n298__i0__net2 n307__i0__net2 84.56e-3
rj2424 n307__i0__net2 n320__i0__net2 85.78e-3
rj2425 n320__i0__net2 n329__i0__net2 84.56e-3
rj2426 n167__i0__i13__net1 n165__i0__i13__net1 125e-3
rj2427 n166__i0__i13__net1 n168__i0__i13__net1 125e-3
rj2428 n27__i0__net3 n25__i0__net3 125e-3
rj2429 n26__i0__net3 n28__i0__net3 125e-3
rj2430 n27__i0__net3 n29__i0__net3 125e-3
rj2431 n30__i0__net3 n28__i0__net3 125e-3
rj2432 n35__i0__net3 n31__i0__net3 125e-3
rj2433 n32__i0__net3 n35__i0__net3 125e-3
rj2434 n37__i0__net3 n14__i0__net3 250e-3
rj2435 n16__i0__net3 n37__i0__net3 250e-3
rj2436 n43__i0__net3 n41__i0__net3 125e-3
rj2437 n42__i0__net3 n43__i0__net3 125e-3
rj2438 n169__i0__i13__net1 n219__i0__i13__net1 93.48e-3
rj2439 n219__i0__i13__net1 n220__i0__i13__net1 85.78e-3
rj2440 n220__i0__i13__net1 n209__i0__i13__net1 167.9e-3
rj2441 n187__i0__i13__net1 n219__i0__i13__net1 83.33e-3
rj2442 n198__i0__i13__net1 n220__i0__i13__net1 83.33e-3
rj2443 n170__i0__i13__net1 n189__i0__i13__net1 156e-3
rj2444 n189__i0__i13__net1 n200__i0__i13__net1 85.78e-3
rj2445 n200__i0__i13__net1 n211__i0__i13__net1 84.56e-3
rj2446 n183__i0__i13__net1 n221__i0__i13__net1 156e-3
rj2447 n221__i0__i13__net1 n222__i0__i13__net1 85.78e-3
rj2448 n222__i0__i13__net1 n217__i0__i13__net1 167.9e-3
rj2449 n195__i0__i13__net1 n221__i0__i13__net1 83.33e-3
rj2450 n206__i0__i13__net1 n222__i0__i13__net1 83.33e-3
rj2451 n184__i0__i13__net1 n223__i0__i13__net1 154.8e-3
rj2452 n223__i0__i13__net1 n224__i0__i13__net1 85.78e-3
rj2453 n224__i0__i13__net1 n216__i0__i13__net1 167.9e-3
rj2454 n194__i0__i13__net1 n223__i0__i13__net1 83.33e-3
rj2455 n205__i0__i13__net1 n224__i0__i13__net1 83.33e-3
rj2456 n185__i0__i13__net1 n225__i0__i13__net1 92.26e-3
rj2457 n225__i0__i13__net1 n226__i0__i13__net1 85.78e-3
rj2458 n226__i0__i13__net1 n213__i0__i13__net1 167.9e-3
rj2459 n191__i0__i13__net1 n225__i0__i13__net1 83.33e-3
rj2460 n202__i0__i13__net1 n226__i0__i13__net1 83.33e-3
rj2461 n47__i0__net3 n45__i0__net3 125e-3
rj2462 n46__i0__net3 n47__i0__net3 125e-3
rj2464 n1210__vss n1201__vss 114.7e-3
rj2466 n1201__vss n1213__vss 109.8e-3
rj2468 n1213__vss n1191__vss 114.7e-3
rj2470 n1191__vss n1216__vss 178e-3
rj2472 n1216__vss n1177__vss 114.7e-3
rj2474 n1177__vss n1219__vss 109.8e-3
rj2476 n1219__vss n1165__vss 114.7e-3
rj2478 n1165__vss n1222__vss 111.5e-3
rj2480 n1222__vss n1150__vss 114.7e-3
rj2482 n1150__vss n1225__vss 109.8e-3
rj2484 n1225__vss n1139__vss 114.7e-3
rj2486 n1139__vss n1131__vss 114.7e-3
rj2488 n1131__vss n1125__vss 114.7e-3
rj2490 n1125__vss n1230__vss 109.8e-3
rj2491 n1230__vss n1231__vss 125e-3
rj2492 n1195__vss n1213__vss 125e-3
rj2493 n1178__vss n1216__vss 125e-3
rj2494 n1169__vss n1219__vss 125e-3
rj2495 n1152__vss n1222__vss 125e-3
rj2496 n1143__vss n1225__vss 125e-3
rj2497 n1114__vss n1230__vss 125e-3
rj2499 n1636__vddio n1644__vddio 114.7e-3
rj2501 n1644__vddio n1646__vddio 109.8e-3
rj2503 n1646__vddio n1615__vddio 114.7e-3
rj2505 n1615__vddio n1649__vddio 178e-3
rj2507 n1649__vddio n1651__vddio 114.7e-3
rj2509 n1651__vddio n1653__vddio 109.8e-3
rj2511 n1653__vddio n1655__vddio 114.7e-3
rj2513 n1655__vddio n1657__vddio 111.5e-3
rj2515 n1657__vddio n1659__vddio 114.7e-3
rj2517 n1659__vddio n1566__vddio 109.8e-3
rj2519 n1566__vddio n1662__vddio 115.3e-3
rj2521 n1662__vddio n1664__vddio 115.3e-3
rj2523 n1664__vddio n1666__vddio 112e-3
rj2525 n1666__vddio n1668__vddio 113.7e-3
rj2526 n1668__vddio n1544__vddio 125e-3
rj2527 n1635__vddio n1644__vddio 125e-3
rj2528 n1628__vddio n1646__vddio 125e-3
rj2529 n1614__vddio n1649__vddio 125e-3
rj2530 n1607__vddio n1651__vddio 125e-3
rj2531 n1600__vddio n1653__vddio 125e-3
rj2532 n1593__vddio n1655__vddio 125e-3
rj2533 n1586__vddio n1657__vddio 125e-3
rj2534 n1579__vddio n1659__vddio 125e-3
rj2535 n1565__vddio n1662__vddio 125e-3
rj2536 n1558__vddio n1664__vddio 125e-3
rj2537 n1551__vddio n1666__vddio 125e-3
rj2538 n1206__vss n1232__vss 167.9e-3
rj2539 n1232__vss n1233__vss 85.78e-3
rj2540 n1233__vss n1234__vss 84.56e-3
rj2541 n1234__vss n1235__vss 129.7e-3
rj2542 n1235__vss n1236__vss 87e-3
rj2543 n1236__vss n1237__vss 83.35e-3
rj2544 n1237__vss n1238__vss 84.56e-3
rj2545 n1238__vss n1239__vss 83.35e-3
rj2546 n1239__vss n1240__vss 84.56e-3
rj2547 n1240__vss n1241__vss 85.78e-3
rj2548 n1241__vss n1242__vss 83.35e-3
rj2549 n1242__vss n1243__vss 84.56e-3
rj2550 n1243__vss n1244__vss 84.56e-3
rj2551 n1244__vss n1117__vss 167.9e-3
rj2552 n1198__vss n1232__vss 83.33e-3
rj2553 n1192__vss n1233__vss 83.33e-3
rj2554 n1187__vss n1234__vss 83.33e-3
rj2555 n1181__vss n1235__vss 83.33e-3
rj2556 n1175__vss n1236__vss 83.33e-3
rj2557 n1166__vss n1237__vss 83.33e-3
rj2558 n1161__vss n1238__vss 83.33e-3
rj2559 n1155__vss n1239__vss 83.33e-3
rj2560 n1146__vss n1240__vss 83.33e-3
rj2561 n1140__vss n1241__vss 83.33e-3
rj2562 n1135__vss n1242__vss 83.33e-3
rj2563 n1127__vss n1243__vss 83.33e-3
rj2564 n1121__vss n1244__vss 83.33e-3
rj2565 n1208__vss n1203__vss 167.9e-3
rj2566 n1203__vss n1197__vss 85.78e-3
rj2567 n1197__vss n1245__vss 84.56e-3
rj2568 n1245__vss n1246__vss 129.7e-3
rj2569 n1246__vss n1172__vss 85.78e-3
rj2570 n1172__vss n1171__vss 84.56e-3
rj2571 n1171__vss n1247__vss 84.56e-3
rj2572 n1247__vss n1248__vss 83.35e-3
rj2573 n1248__vss n1151__vss 84.56e-3
rj2574 n1151__vss n1145__vss 85.78e-3
rj2575 n1145__vss n1249__vss 83.35e-3
rj2576 n1249__vss n1132__vss 84.56e-3
rj2577 n1132__vss n1126__vss 85.78e-3
rj2578 n1126__vss n1119__vss 166.7e-3
rj2579 n1189__vss n1245__vss 83.33e-3
rj2580 n1183__vss n1246__vss 83.33e-3
rj2581 n1163__vss n1247__vss 83.33e-3
rj2582 n1157__vss n1248__vss 83.33e-3
rj2583 n1137__vss n1249__vss 83.33e-3
rj2584 n1642__vddio n1629__vddio 84.56e-3
rj2585 n1629__vddio n1622__vddio 85.78e-3
rj2586 n1622__vddio n1621__vddio 84.56e-3
rj2587 n1621__vddio n1608__vddio 129.7e-3
rj2588 n1608__vddio n1601__vddio 84.56e-3
rj2589 n1601__vddio n1594__vddio 85.78e-3
rj2590 n1594__vddio n1587__vddio 84.56e-3
rj2591 n1587__vddio n1580__vddio 83.35e-3
rj2592 n1580__vddio n1573__vddio 84.56e-3
rj2593 n1573__vddio n1572__vddio 85.78e-3
rj2594 n1572__vddio n1559__vddio 83.35e-3
rj2595 n1559__vddio n1552__vddio 84.56e-3
rj2596 n1552__vddio n1545__vddio 83.35e-3
rj2597 n1545__vddio n1538__vddio 85.78e-3
rj2598 n1640__vddio n1669__vddio 167.9e-3
rj2599 n1669__vddio n1670__vddio 85.78e-3
rj2600 n1670__vddio n1671__vddio 84.56e-3
rj2601 n1671__vddio n1672__vddio 129.7e-3
rj2602 n1672__vddio n1673__vddio 84.56e-3
rj2603 n1673__vddio n1674__vddio 85.78e-3
rj2604 n1674__vddio n1675__vddio 84.56e-3
rj2605 n1675__vddio n1676__vddio 83.35e-3
rj2606 n1676__vddio n1677__vddio 84.56e-3
rj2607 n1677__vddio n1678__vddio 85.78e-3
rj2608 n1678__vddio n1679__vddio 83.35e-3
rj2609 n1679__vddio n1680__vddio 84.56e-3
rj2610 n1680__vddio n1681__vddio 83.35e-3
rj2611 n1681__vddio n1541__vddio 169.1e-3
rj2612 n1632__vddio n1669__vddio 83.33e-3
rj2613 n1625__vddio n1670__vddio 83.33e-3
rj2614 n1619__vddio n1671__vddio 83.33e-3
rj2615 n1611__vddio n1672__vddio 83.33e-3
rj2616 n1604__vddio n1673__vddio 83.33e-3
rj2617 n1597__vddio n1674__vddio 83.33e-3
rj2618 n1590__vddio n1675__vddio 83.33e-3
rj2619 n1583__vddio n1676__vddio 83.33e-3
rj2620 n1576__vddio n1677__vddio 83.33e-3
rj2621 n1570__vddio n1678__vddio 83.33e-3
rj2622 n1562__vddio n1679__vddio 83.33e-3
rj2623 n1555__vddio n1680__vddio 83.33e-3
rj2624 n1548__vddio n1681__vddio 83.33e-3
rj2625 n1637__vddio n1682__vddio 167.9e-3
rj2626 n1682__vddio n1683__vddio 85.78e-3
rj2627 n1683__vddio n1684__vddio 84.56e-3
rj2628 n1684__vddio n1685__vddio 129.7e-3
rj2629 n1685__vddio n1686__vddio 84.56e-3
rj2630 n1686__vddio n1687__vddio 85.78e-3
rj2631 n1687__vddio n1688__vddio 84.56e-3
rj2632 n1688__vddio n1689__vddio 83.35e-3
rj2633 n1689__vddio n1690__vddio 84.56e-3
rj2634 n1690__vddio n1691__vddio 85.78e-3
rj2635 n1691__vddio n1692__vddio 83.35e-3
rj2636 n1692__vddio n1693__vddio 84.56e-3
rj2637 n1693__vddio n1694__vddio 83.35e-3
rj2638 n1694__vddio n1543__vddio 169.1e-3
rj2639 n1634__vddio n1682__vddio 83.33e-3
rj2640 n1627__vddio n1683__vddio 83.33e-3
rj2641 n1616__vddio n1684__vddio 83.33e-3
rj2642 n1613__vddio n1685__vddio 83.33e-3
rj2643 n1606__vddio n1686__vddio 83.33e-3
rj2644 n1599__vddio n1687__vddio 83.33e-3
rj2645 n1592__vddio n1688__vddio 83.33e-3
rj2646 n1585__vddio n1689__vddio 83.33e-3
rj2647 n1578__vddio n1690__vddio 83.33e-3
rj2648 n1567__vddio n1691__vddio 83.33e-3
rj2649 n1564__vddio n1692__vddio 83.33e-3
rj2650 n1557__vddio n1693__vddio 83.33e-3
rj2651 n1550__vddio n1694__vddio 83.33e-3
rj2653 n1695__vddio n1697__vddio 258.8e-3
rj2655 n1697__vddio n1699__vddio 279.8e-3
rj2657 n1699__vddio n1701__vddio 279.8e-3
rj2658 n1701__vddio n1702__vddio 8.333e-3
rj2660 n1250__vss n1252__vss 258.8e-3
rj2662 n1252__vss n1254__vss 279.8e-3
rj2664 n1254__vss n1256__vss 279.8e-3
rj2665 n1256__vss n1257__vss 8.333e-3
rj2666 n31__i0__i12__net1 n29__i0__i12__net1 125e-3
rj2667 n30__i0__i12__net1 n32__i0__i12__net1 125e-3
rj2668 n35__i0__i12__net1 n33__i0__i12__net1 125e-3
rj2669 n34__i0__i12__net1 n36__i0__i12__net1 125e-3
rj2670 n43__i0__i12__net1 n37__i0__i12__net1 125e-3
rj2671 n38__i0__i12__net1 n44__i0__i12__net1 125e-3
rj2672 n45__i0__i12__net1 n39__i0__i12__net1 125e-3
rj2673 n40__i0__i12__net1 n46__i0__i12__net1 125e-3
rj2674 n45__i0__i12__net1 n41__i0__i12__net1 125e-3
rj2675 n42__i0__i12__net1 n46__i0__i12__net1 125e-3
rj2676 n51__i0__i12__net1 n49__i0__i12__net1 125e-3
rj2677 n50__i0__i12__net1 n52__i0__i12__net1 125e-3
rj2678 n78__i0__net3 n67__i0__net3 115.3e-3
rj2679 n67__i0__net3 n80__i0__net3 113.7e-3
rj2680 n80__i0__net3 n49__i0__net3 110.4e-3
rj2681 n49__i0__net3 n57__i0__net3 160.9e-3
rj2682 n57__i0__net3 n81__i0__net3 240.5e-3
rj2683 n81__i0__net3 n82__i0__net3 110.4e-3
rj2684 n82__i0__net3 n83__i0__net3 114.7e-3
rj2685 n83__i0__net3 n76__i0__net3 236.5e-3
rj2686 n58__i0__net3 n80__i0__net3 125e-3
rj2687 n54__i0__net3 n81__i0__net3 125e-3
rj2688 n64__i0__net3 n82__i0__net3 125e-3
rj2689 n71__i0__net3 n83__i0__net3 125e-3
rj2690 n51__i0__i12__net1 n26__i0__i12__net1 250e-3
rj2691 n28__i0__i12__net1 n52__i0__i12__net1 250e-3
rj2692 n13__i0__net4 n24__i0__net4 125e-3
rj2693 n24__i0__net4 n14__i0__net4 125e-3
rj2694 n61__i0__i12__net1 n63__i0__i12__net1 230.7e-3
rj2695 n63__i0__i12__net1 n60__i0__i12__net1 237.2e-3
rj2696 n26__i0__net4 n15__i0__net4 125e-3
rj2697 n32__pinin n33__pinin 31.69e-3
rj2698 n33__pinin n31__pinin 29.64e-3
rj2699 n31__pinin n30__pinin 100.9e-3
rj2700 n21__i0__net4 n27__i0__net4 982.6e-3
rj2701 n27__i0__net4 n17__i0__net4 27.73e-3
rj2702 n17__i0__net4 n28__i0__net4 210.2e-3
rj2703 n28__i0__net4 n16__i0__net4 57.93e-3
rj2705 n27__i0__net4 n18__i0__net4 84.35e-3
rj2706 n17__pinout n18__pinout 30.52e-3
rj2707 n18__pinout n16__pinout 28.84e-3
rj2708 n16__pinout n15__pinout 101.7e-3
rj2709 n11__i0__i11__outinv n7__i0__i11__outinv 2.1991
rj2710 n11__i0__i11__outinv n10__i0__i11__outinv 147e-3
rk2 n2__chipdriverout n4__chipdriverout 124.4e-3
rk3 n4__chipdriverout n5__chipdriverout 234.5e-3
rk4 n5__chipdriverout n6__chipdriverout 339.7e-3
rk5 n6__chipdriverout n7__chipdriverout 140.3e-3
rk6 n7__chipdriverout n8__chipdriverout 221.8e-3
rk7 n8__chipdriverout n9__chipdriverout 355.7e-3
rk8 n9__chipdriverout n10__chipdriverout 137.1e-3
rk9 n10__chipdriverout n11__chipdriverout 223.4e-3
rk10 n11__chipdriverout n12__chipdriverout 336.5e-3
rk11 n12__chipdriverout n13__chipdriverout 154.7e-3
rk12 n13__chipdriverout n14__chipdriverout 300.1e-3
rk13 n3__chipdriverout n4__chipdriverout 3.1
rk14 n3__chipdriverout n7__chipdriverout 3.1
rk15 n3__chipdriverout n10__chipdriverout 3.1
rk16 n3__chipdriverout n13__chipdriverout 3.1
rk18 n17__chipdriverout n18__chipdriverout 9.898e-3
rk19 n18__chipdriverout n19__chipdriverout 363.7e-3
rk20 n19__chipdriverout n20__chipdriverout 223.4e-3
rk21 n20__chipdriverout n21__chipdriverout 113.2e-3
rk22 n21__chipdriverout n22__chipdriverout 362.1e-3
rk23 n22__chipdriverout n23__chipdriverout 239.3e-3
rk24 n23__chipdriverout n24__chipdriverout 119.6e-3
rk26 n16__chipdriverout n17__chipdriverout 5.7692
rk27 n16__chipdriverout n20__chipdriverout 3.75
rk28 n16__chipdriverout n23__chipdriverout 3.75
rk29 n2__i0__i14__net1 n61__i0__i14__net1 125e-3
rk30 n4__i0__i14__net1 n62__i0__i14__net1 125e-3
rk31 n2__vss n3__vss 54.44e-3
rk32 n3__vss n4__vss 360.5e-3
rk33 n4__vss n5__vss 294.3e-3
rk34 n5__vss n6__vss 42.07e-3
rk35 n6__vss n7__vss 360.5e-3
rk36 n7__vss n8__vss 185e-3
rk37 n8__vss n9__vss 262e-3
rk38 n1__vss n2__vss 3.75
rk39 n1__vss n5__vss 3.75
rk40 n1__vss n8__vss 5.7692
rk42 n2__vddio n4__vddio 29.7e-3
rk43 n4__vddio n5__vddio 330.8e-3
rk44 n5__vddio n6__vddio 338.1e-3
rk45 n6__vddio n7__vddio 42.07e-3
rk46 n7__vddio n8__vddio 316.6e-3
rk47 n8__vddio n9__vddio 357.3e-3
rk48 n9__vddio n10__vddio 39.59e-3
rk49 n10__vddio n11__vddio 319.1e-3
rk50 n11__vddio n12__vddio 338.1e-3
rk51 n12__vddio n13__vddio 51.97e-3
rk52 n13__vddio n14__vddio 389.7e-3
rk53 n3__vddio n4__vddio 3.1
rk54 n3__vddio n7__vddio 3.1
rk55 n3__vddio n10__vddio 3.1
rk56 n3__vddio n13__vddio 3.1
rk60 n40__chipdriverout n42__chipdriverout 207.4e-3
rk61 n42__chipdriverout n43__chipdriverout 153.1e-3
rk62 n43__chipdriverout n44__chipdriverout 338.1e-3
rk63 n44__chipdriverout n45__chipdriverout 223.4e-3
rk64 n45__chipdriverout n46__chipdriverout 137.1e-3
rk65 n46__chipdriverout n47__chipdriverout 357.3e-3
rk66 n47__chipdriverout n48__chipdriverout 220.2e-3
rk67 n48__chipdriverout n49__chipdriverout 140.3e-3
rk68 n49__chipdriverout n50__chipdriverout 338.1e-3
rk69 n50__chipdriverout n51__chipdriverout 236.1e-3
rk70 n51__chipdriverout n52__chipdriverout 124.4e-3
rk72 n41__chipdriverout n42__chipdriverout 3.1
rk73 n41__chipdriverout n45__chipdriverout 3.1
rk74 n41__chipdriverout n48__chipdriverout 3.1
rk75 n41__chipdriverout n51__chipdriverout 3.1
rk77 n56__chipdriverout n57__chipdriverout 12.37e-3
rk78 n57__chipdriverout n58__chipdriverout 360.5e-3
rk79 n58__chipdriverout n59__chipdriverout 223.4e-3
rk80 n59__chipdriverout n60__chipdriverout 114.8e-3
rk81 n60__chipdriverout n61__chipdriverout 360.5e-3
rk82 n61__chipdriverout n62__chipdriverout 239.3e-3
rk83 n62__chipdriverout n63__chipdriverout 118e-3
rk85 n55__chipdriverout n56__chipdriverout 5.7692
rk86 n55__chipdriverout n59__chipdriverout 3.75
rk87 n55__chipdriverout n62__chipdriverout 3.75
rk88 n10__i0__i14__net1 n73__i0__i14__net1 125e-3
rk89 n12__i0__i14__net1 n74__i0__i14__net1 125e-3
rk90 n15__vss n16__vss 54.44e-3
rk91 n16__vss n17__vss 360.5e-3
rk92 n17__vss n18__vss 294.3e-3
rk93 n18__vss n19__vss 42.07e-3
rk94 n19__vss n20__vss 360.5e-3
rk95 n20__vss n21__vss 185e-3
rk96 n21__vss n22__vss 262e-3
rk97 n14__vss n15__vss 3.75
rk98 n14__vss n18__vss 3.75
rk99 n14__vss n21__vss 5.7692
rk101 n23__vddio n25__vddio 29.7e-3
rk102 n25__vddio n26__vddio 330.8e-3
rk103 n26__vddio n27__vddio 338.1e-3
rk104 n27__vddio n28__vddio 42.07e-3
rk105 n28__vddio n29__vddio 316.6e-3
rk106 n29__vddio n30__vddio 357.3e-3
rk107 n30__vddio n31__vddio 39.59e-3
rk108 n31__vddio n32__vddio 319.1e-3
rk109 n32__vddio n33__vddio 338.1e-3
rk110 n33__vddio n34__vddio 51.97e-3
rk111 n34__vddio n35__vddio 389.7e-3
rk112 n24__vddio n25__vddio 3.1
rk113 n24__vddio n28__vddio 3.1
rk114 n24__vddio n31__vddio 3.1
rk115 n24__vddio n34__vddio 3.1
rk116 n14__i0__i14__net1 n85__i0__i14__net1 125e-3
rk117 n16__i0__i14__net1 n86__i0__i14__net1 125e-3
rk119 n79__chipdriverout n81__chipdriverout 207.4e-3
rk120 n81__chipdriverout n82__chipdriverout 153.1e-3
rk121 n82__chipdriverout n83__chipdriverout 338.1e-3
rk122 n83__chipdriverout n84__chipdriverout 223.4e-3
rk123 n84__chipdriverout n85__chipdriverout 137.1e-3
rk124 n85__chipdriverout n86__chipdriverout 357.3e-3
rk125 n86__chipdriverout n87__chipdriverout 220.2e-3
rk126 n87__chipdriverout n88__chipdriverout 140.3e-3
rk127 n88__chipdriverout n89__chipdriverout 338.1e-3
rk128 n89__chipdriverout n90__chipdriverout 236.1e-3
rk129 n90__chipdriverout n91__chipdriverout 124.4e-3
rk131 n80__chipdriverout n81__chipdriverout 3.1
rk132 n80__chipdriverout n84__chipdriverout 3.1
rk133 n80__chipdriverout n87__chipdriverout 3.1
rk134 n80__chipdriverout n90__chipdriverout 3.1
rk136 n95__chipdriverout n96__chipdriverout 12.37e-3
rk137 n96__chipdriverout n97__chipdriverout 360.5e-3
rk138 n97__chipdriverout n98__chipdriverout 223.4e-3
rk139 n98__chipdriverout n99__chipdriverout 114.8e-3
rk140 n99__chipdriverout n100__chipdriverout 360.5e-3
rk141 n100__chipdriverout n101__chipdriverout 239.3e-3
rk142 n101__chipdriverout n102__chipdriverout 118e-3
rk144 n94__chipdriverout n95__chipdriverout 5.7692
rk145 n94__chipdriverout n98__chipdriverout 3.75
rk146 n94__chipdriverout n101__chipdriverout 3.75
rk147 n18__i0__i14__net1 n89__i0__i14__net1 125e-3
rk148 n20__i0__i14__net1 n90__i0__i14__net1 125e-3
rk149 n28__vss n29__vss 54.44e-3
rk150 n29__vss n30__vss 360.5e-3
rk151 n30__vss n31__vss 294.3e-3
rk152 n31__vss n32__vss 42.07e-3
rk153 n32__vss n33__vss 360.5e-3
rk154 n33__vss n34__vss 185e-3
rk155 n34__vss n35__vss 262e-3
rk156 n27__vss n28__vss 3.75
rk157 n27__vss n31__vss 3.75
rk158 n27__vss n34__vss 5.7692
rk160 n44__vddio n46__vddio 29.7e-3
rk161 n46__vddio n47__vddio 330.8e-3
rk162 n47__vddio n48__vddio 338.1e-3
rk163 n48__vddio n49__vddio 42.07e-3
rk164 n49__vddio n50__vddio 316.6e-3
rk165 n50__vddio n51__vddio 357.3e-3
rk166 n51__vddio n52__vddio 39.59e-3
rk167 n52__vddio n53__vddio 319.1e-3
rk168 n53__vddio n54__vddio 338.1e-3
rk169 n54__vddio n55__vddio 51.97e-3
rk170 n55__vddio n56__vddio 389.7e-3
rk171 n45__vddio n46__vddio 3.1
rk172 n45__vddio n49__vddio 3.1
rk173 n45__vddio n52__vddio 3.1
rk174 n45__vddio n55__vddio 3.1
rk175 n21__i0__i14__net1 n101__i0__i14__net1 125e-3
rk176 n23__i0__i14__net1 n102__i0__i14__net1 125e-3
rk178 n118__chipdriverout n120__chipdriverout 207.4e-3
rk179 n120__chipdriverout n121__chipdriverout 153.1e-3
rk180 n121__chipdriverout n122__chipdriverout 338.1e-3
rk181 n122__chipdriverout n123__chipdriverout 223.4e-3
rk182 n123__chipdriverout n124__chipdriverout 137.1e-3
rk183 n124__chipdriverout n125__chipdriverout 357.3e-3
rk184 n125__chipdriverout n126__chipdriverout 220.2e-3
rk185 n126__chipdriverout n127__chipdriverout 140.3e-3
rk186 n127__chipdriverout n128__chipdriverout 338.1e-3
rk187 n128__chipdriverout n129__chipdriverout 236.1e-3
rk188 n129__chipdriverout n130__chipdriverout 124.4e-3
rk190 n119__chipdriverout n120__chipdriverout 3.1
rk191 n119__chipdriverout n123__chipdriverout 3.1
rk192 n119__chipdriverout n126__chipdriverout 3.1
rk193 n119__chipdriverout n129__chipdriverout 3.1
rk195 n134__chipdriverout n135__chipdriverout 12.37e-3
rk196 n135__chipdriverout n136__chipdriverout 360.5e-3
rk197 n136__chipdriverout n137__chipdriverout 223.4e-3
rk198 n137__chipdriverout n138__chipdriverout 114.8e-3
rk199 n138__chipdriverout n139__chipdriverout 360.5e-3
rk200 n139__chipdriverout n140__chipdriverout 239.3e-3
rk201 n140__chipdriverout n141__chipdriverout 118e-3
rk203 n133__chipdriverout n134__chipdriverout 5.7692
rk204 n133__chipdriverout n137__chipdriverout 3.75
rk205 n133__chipdriverout n140__chipdriverout 3.75
rk206 n26__i0__i14__net1 n105__i0__i14__net1 125e-3
rk207 n28__i0__i14__net1 n106__i0__i14__net1 125e-3
rk208 n41__vss n42__vss 54.44e-3
rk209 n42__vss n43__vss 360.5e-3
rk210 n43__vss n44__vss 294.3e-3
rk211 n44__vss n45__vss 42.07e-3
rk212 n45__vss n46__vss 360.5e-3
rk213 n46__vss n47__vss 185e-3
rk214 n47__vss n48__vss 262e-3
rk215 n40__vss n41__vss 3.75
rk216 n40__vss n44__vss 3.75
rk217 n40__vss n47__vss 5.7692
rk219 n65__vddio n67__vddio 29.7e-3
rk220 n67__vddio n68__vddio 330.8e-3
rk221 n68__vddio n69__vddio 338.1e-3
rk222 n69__vddio n70__vddio 42.07e-3
rk223 n70__vddio n71__vddio 316.6e-3
rk224 n71__vddio n72__vddio 357.3e-3
rk225 n72__vddio n73__vddio 39.59e-3
rk226 n73__vddio n74__vddio 319.1e-3
rk227 n74__vddio n75__vddio 338.1e-3
rk228 n75__vddio n76__vddio 51.97e-3
rk229 n76__vddio n77__vddio 389.7e-3
rk230 n66__vddio n67__vddio 3.1
rk231 n66__vddio n70__vddio 3.1
rk232 n66__vddio n73__vddio 3.1
rk233 n66__vddio n76__vddio 3.1
rk234 n29__i0__i14__net1 n117__i0__i14__net1 125e-3
rk235 n31__i0__i14__net1 n118__i0__i14__net1 125e-3
rk237 n158__chipdriverout n159__chipdriverout 12.37e-3
rk238 n159__chipdriverout n160__chipdriverout 360.5e-3
rk239 n160__chipdriverout n161__chipdriverout 223.4e-3
rk240 n161__chipdriverout n162__chipdriverout 114.8e-3
rk241 n162__chipdriverout n163__chipdriverout 360.5e-3
rk242 n163__chipdriverout n164__chipdriverout 239.3e-3
rk243 n164__chipdriverout n165__chipdriverout 118e-3
rk245 n157__chipdriverout n158__chipdriverout 5.7692
rk246 n157__chipdriverout n161__chipdriverout 3.75
rk247 n157__chipdriverout n164__chipdriverout 3.75
rk249 n168__chipdriverout n170__chipdriverout 207.4e-3
rk250 n170__chipdriverout n171__chipdriverout 153.1e-3
rk251 n171__chipdriverout n172__chipdriverout 338.1e-3
rk252 n172__chipdriverout n173__chipdriverout 223.4e-3
rk253 n173__chipdriverout n174__chipdriverout 137.1e-3
rk254 n174__chipdriverout n175__chipdriverout 357.3e-3
rk255 n175__chipdriverout n176__chipdriverout 220.2e-3
rk256 n176__chipdriverout n177__chipdriverout 140.3e-3
rk257 n177__chipdriverout n178__chipdriverout 338.1e-3
rk258 n178__chipdriverout n179__chipdriverout 236.1e-3
rk259 n179__chipdriverout n180__chipdriverout 124.4e-3
rk261 n169__chipdriverout n170__chipdriverout 3.1
rk262 n169__chipdriverout n173__chipdriverout 3.1
rk263 n169__chipdriverout n176__chipdriverout 3.1
rk264 n169__chipdriverout n179__chipdriverout 3.1
rk265 n34__i0__i14__net1 n121__i0__i14__net1 125e-3
rk266 n36__i0__i14__net1 n122__i0__i14__net1 125e-3
rk267 n54__vss n55__vss 54.44e-3
rk268 n55__vss n56__vss 360.5e-3
rk269 n56__vss n57__vss 294.3e-3
rk270 n57__vss n58__vss 42.07e-3
rk271 n58__vss n59__vss 360.5e-3
rk272 n59__vss n60__vss 185e-3
rk273 n60__vss n61__vss 262e-3
rk274 n53__vss n54__vss 3.75
rk275 n53__vss n57__vss 3.75
rk276 n53__vss n60__vss 5.7692
rk278 n86__vddio n88__vddio 29.7e-3
rk279 n88__vddio n89__vddio 330.8e-3
rk280 n89__vddio n90__vddio 338.1e-3
rk281 n90__vddio n91__vddio 42.07e-3
rk282 n91__vddio n92__vddio 316.6e-3
rk283 n92__vddio n93__vddio 357.3e-3
rk284 n93__vddio n94__vddio 39.59e-3
rk285 n94__vddio n95__vddio 319.1e-3
rk286 n95__vddio n96__vddio 338.1e-3
rk287 n96__vddio n97__vddio 51.97e-3
rk288 n97__vddio n98__vddio 389.7e-3
rk289 n87__vddio n88__vddio 3.1
rk290 n87__vddio n91__vddio 3.1
rk291 n87__vddio n94__vddio 3.1
rk292 n87__vddio n97__vddio 3.1
rk293 n37__i0__i14__net1 n133__i0__i14__net1 125e-3
rk294 n39__i0__i14__net1 n134__i0__i14__net1 125e-3
rk296 n197__chipdriverout n198__chipdriverout 12.37e-3
rk297 n198__chipdriverout n199__chipdriverout 360.5e-3
rk298 n199__chipdriverout n200__chipdriverout 223.4e-3
rk299 n200__chipdriverout n201__chipdriverout 114.8e-3
rk300 n201__chipdriverout n202__chipdriverout 360.5e-3
rk301 n202__chipdriverout n203__chipdriverout 239.3e-3
rk302 n203__chipdriverout n204__chipdriverout 118e-3
rk304 n196__chipdriverout n197__chipdriverout 5.7692
rk305 n196__chipdriverout n200__chipdriverout 3.75
rk306 n196__chipdriverout n203__chipdriverout 3.75
rk308 n207__chipdriverout n209__chipdriverout 207.4e-3
rk309 n209__chipdriverout n210__chipdriverout 153.1e-3
rk310 n210__chipdriverout n211__chipdriverout 338.1e-3
rk311 n211__chipdriverout n212__chipdriverout 223.4e-3
rk312 n212__chipdriverout n213__chipdriverout 137.1e-3
rk313 n213__chipdriverout n214__chipdriverout 357.3e-3
rk314 n214__chipdriverout n215__chipdriverout 220.2e-3
rk315 n215__chipdriverout n216__chipdriverout 140.3e-3
rk316 n216__chipdriverout n217__chipdriverout 338.1e-3
rk317 n217__chipdriverout n218__chipdriverout 236.1e-3
rk318 n218__chipdriverout n219__chipdriverout 124.4e-3
rk320 n208__chipdriverout n209__chipdriverout 3.1
rk321 n208__chipdriverout n212__chipdriverout 3.1
rk322 n208__chipdriverout n215__chipdriverout 3.1
rk323 n208__chipdriverout n218__chipdriverout 3.1
rk324 n42__i0__i14__net1 n137__i0__i14__net1 125e-3
rk325 n44__i0__i14__net1 n138__i0__i14__net1 125e-3
rk327 n107__vddio n109__vddio 29.7e-3
rk328 n109__vddio n110__vddio 330.8e-3
rk329 n110__vddio n111__vddio 338.1e-3
rk330 n111__vddio n112__vddio 42.07e-3
rk331 n112__vddio n113__vddio 316.6e-3
rk332 n113__vddio n114__vddio 357.3e-3
rk333 n114__vddio n115__vddio 39.59e-3
rk334 n115__vddio n116__vddio 319.1e-3
rk335 n116__vddio n117__vddio 338.1e-3
rk336 n117__vddio n118__vddio 51.97e-3
rk337 n118__vddio n119__vddio 389.7e-3
rk338 n108__vddio n109__vddio 3.1
rk339 n108__vddio n112__vddio 3.1
rk340 n108__vddio n115__vddio 3.1
rk341 n108__vddio n118__vddio 3.1
rk342 n67__vss n68__vss 54.44e-3
rk343 n68__vss n69__vss 360.5e-3
rk344 n69__vss n70__vss 294.3e-3
rk345 n70__vss n71__vss 42.07e-3
rk346 n71__vss n72__vss 360.5e-3
rk347 n72__vss n73__vss 185e-3
rk348 n73__vss n74__vss 262e-3
rk349 n66__vss n67__vss 3.75
rk350 n66__vss n70__vss 3.75
rk351 n66__vss n73__vss 5.7692
rk352 n45__i0__i14__net1 n149__i0__i14__net1 125e-3
rk353 n47__i0__i14__net1 n150__i0__i14__net1 125e-3
rk355 n236__chipdriverout n237__chipdriverout 12.37e-3
rk356 n237__chipdriverout n238__chipdriverout 360.5e-3
rk357 n238__chipdriverout n239__chipdriverout 223.4e-3
rk358 n239__chipdriverout n240__chipdriverout 114.8e-3
rk359 n240__chipdriverout n241__chipdriverout 360.5e-3
rk360 n241__chipdriverout n242__chipdriverout 239.3e-3
rk361 n242__chipdriverout n243__chipdriverout 118e-3
rk363 n235__chipdriverout n236__chipdriverout 5.7692
rk364 n235__chipdriverout n239__chipdriverout 3.75
rk365 n235__chipdriverout n242__chipdriverout 3.75
rk367 n246__chipdriverout n248__chipdriverout 207.4e-3
rk368 n248__chipdriverout n249__chipdriverout 153.1e-3
rk369 n249__chipdriverout n250__chipdriverout 338.1e-3
rk370 n250__chipdriverout n251__chipdriverout 223.4e-3
rk371 n251__chipdriverout n252__chipdriverout 137.1e-3
rk372 n252__chipdriverout n253__chipdriverout 357.3e-3
rk373 n253__chipdriverout n254__chipdriverout 220.2e-3
rk374 n254__chipdriverout n255__chipdriverout 140.3e-3
rk375 n255__chipdriverout n256__chipdriverout 338.1e-3
rk376 n256__chipdriverout n257__chipdriverout 236.1e-3
rk377 n257__chipdriverout n258__chipdriverout 124.4e-3
rk379 n247__chipdriverout n248__chipdriverout 3.1
rk380 n247__chipdriverout n251__chipdriverout 3.1
rk381 n247__chipdriverout n254__chipdriverout 3.1
rk382 n247__chipdriverout n257__chipdriverout 3.1
rk383 n50__i0__i14__net1 n153__i0__i14__net1 125e-3
rk384 n52__i0__i14__net1 n154__i0__i14__net1 125e-3
rk386 n128__vddio n130__vddio 29.7e-3
rk387 n130__vddio n131__vddio 330.8e-3
rk388 n131__vddio n132__vddio 338.1e-3
rk389 n132__vddio n133__vddio 42.07e-3
rk390 n133__vddio n134__vddio 316.6e-3
rk391 n134__vddio n135__vddio 357.3e-3
rk392 n135__vddio n136__vddio 39.59e-3
rk393 n136__vddio n137__vddio 319.1e-3
rk394 n137__vddio n138__vddio 338.1e-3
rk395 n138__vddio n139__vddio 51.97e-3
rk396 n139__vddio n140__vddio 389.7e-3
rk397 n129__vddio n130__vddio 3.1
rk398 n129__vddio n133__vddio 3.1
rk399 n129__vddio n136__vddio 3.1
rk400 n129__vddio n139__vddio 3.1
rk401 n80__vss n81__vss 54.44e-3
rk402 n81__vss n82__vss 360.5e-3
rk403 n82__vss n83__vss 294.3e-3
rk404 n83__vss n84__vss 42.07e-3
rk405 n84__vss n85__vss 360.5e-3
rk406 n85__vss n86__vss 185e-3
rk407 n86__vss n87__vss 262e-3
rk408 n79__vss n80__vss 3.75
rk409 n79__vss n83__vss 3.75
rk410 n79__vss n86__vss 5.7692
rk411 n53__i0__i14__net1 n165__i0__i14__net1 125e-3
rk412 n55__i0__i14__net1 n166__i0__i14__net1 125e-3
rk414 n275__chipdriverout n276__chipdriverout 12.37e-3
rk415 n276__chipdriverout n277__chipdriverout 360.5e-3
rk416 n277__chipdriverout n278__chipdriverout 223.4e-3
rk417 n278__chipdriverout n279__chipdriverout 114.8e-3
rk418 n279__chipdriverout n280__chipdriverout 360.5e-3
rk419 n280__chipdriverout n281__chipdriverout 239.3e-3
rk420 n281__chipdriverout n282__chipdriverout 118e-3
rk422 n274__chipdriverout n275__chipdriverout 5.7692
rk423 n274__chipdriverout n278__chipdriverout 3.75
rk424 n274__chipdriverout n281__chipdriverout 3.75
rk426 n285__chipdriverout n287__chipdriverout 207.4e-3
rk427 n287__chipdriverout n288__chipdriverout 153.1e-3
rk428 n288__chipdriverout n289__chipdriverout 338.1e-3
rk429 n289__chipdriverout n290__chipdriverout 223.4e-3
rk430 n290__chipdriverout n291__chipdriverout 137.1e-3
rk431 n291__chipdriverout n292__chipdriverout 357.3e-3
rk432 n292__chipdriverout n293__chipdriverout 220.2e-3
rk433 n293__chipdriverout n294__chipdriverout 140.3e-3
rk434 n294__chipdriverout n295__chipdriverout 338.1e-3
rk435 n295__chipdriverout n296__chipdriverout 236.1e-3
rk436 n296__chipdriverout n297__chipdriverout 124.4e-3
rk438 n286__chipdriverout n287__chipdriverout 3.1
rk439 n286__chipdriverout n290__chipdriverout 3.1
rk440 n286__chipdriverout n293__chipdriverout 3.1
rk441 n286__chipdriverout n296__chipdriverout 3.1
rk442 n58__i0__i14__net1 n169__i0__i14__net1 125e-3
rk443 n60__i0__i14__net1 n170__i0__i14__net1 125e-3
rk445 n149__vddio n151__vddio 29.7e-3
rk446 n151__vddio n152__vddio 330.8e-3
rk447 n152__vddio n153__vddio 338.1e-3
rk448 n153__vddio n154__vddio 42.07e-3
rk449 n154__vddio n155__vddio 316.6e-3
rk450 n155__vddio n156__vddio 357.3e-3
rk451 n156__vddio n157__vddio 39.59e-3
rk452 n157__vddio n158__vddio 319.1e-3
rk453 n158__vddio n159__vddio 338.1e-3
rk454 n159__vddio n160__vddio 51.97e-3
rk455 n160__vddio n161__vddio 389.7e-3
rk456 n150__vddio n151__vddio 3.1
rk457 n150__vddio n154__vddio 3.1
rk458 n150__vddio n157__vddio 3.1
rk459 n150__vddio n160__vddio 3.1
rk460 n93__vss n94__vss 54.44e-3
rk461 n94__vss n95__vss 360.5e-3
rk462 n95__vss n96__vss 294.3e-3
rk463 n96__vss n97__vss 42.07e-3
rk464 n97__vss n98__vss 360.5e-3
rk465 n98__vss n99__vss 185e-3
rk466 n99__vss n100__vss 262e-3
rk467 n92__vss n93__vss 3.75
rk468 n92__vss n96__vss 3.75
rk469 n92__vss n99__vss 5.7692
rk470 n65__i0__i14__net1 n181__i0__i14__net1 125e-3
rk471 n67__i0__i14__net1 n182__i0__i14__net1 125e-3
rk473 n314__chipdriverout n315__chipdriverout 12.37e-3
rk474 n315__chipdriverout n316__chipdriverout 360.5e-3
rk475 n316__chipdriverout n317__chipdriverout 223.4e-3
rk476 n317__chipdriverout n318__chipdriverout 114.8e-3
rk477 n318__chipdriverout n319__chipdriverout 360.5e-3
rk478 n319__chipdriverout n320__chipdriverout 239.3e-3
rk479 n320__chipdriverout n321__chipdriverout 118e-3
rk481 n313__chipdriverout n314__chipdriverout 5.7692
rk482 n313__chipdriverout n317__chipdriverout 3.75
rk483 n313__chipdriverout n320__chipdriverout 3.75
rk485 n324__chipdriverout n326__chipdriverout 207.4e-3
rk486 n326__chipdriverout n327__chipdriverout 153.1e-3
rk487 n327__chipdriverout n328__chipdriverout 338.1e-3
rk488 n328__chipdriverout n329__chipdriverout 223.4e-3
rk489 n329__chipdriverout n330__chipdriverout 137.1e-3
rk490 n330__chipdriverout n331__chipdriverout 357.3e-3
rk491 n331__chipdriverout n332__chipdriverout 220.2e-3
rk492 n332__chipdriverout n333__chipdriverout 140.3e-3
rk493 n333__chipdriverout n334__chipdriverout 338.1e-3
rk494 n334__chipdriverout n335__chipdriverout 236.1e-3
rk495 n335__chipdriverout n336__chipdriverout 124.4e-3
rk497 n325__chipdriverout n326__chipdriverout 3.1
rk498 n325__chipdriverout n329__chipdriverout 3.1
rk499 n325__chipdriverout n332__chipdriverout 3.1
rk500 n325__chipdriverout n335__chipdriverout 3.1
rk501 n78__i0__i14__net1 n185__i0__i14__net1 125e-3
rk502 n80__i0__i14__net1 n186__i0__i14__net1 125e-3
rk504 n170__vddio n172__vddio 29.7e-3
rk505 n172__vddio n173__vddio 330.8e-3
rk506 n173__vddio n174__vddio 338.1e-3
rk507 n174__vddio n175__vddio 42.07e-3
rk508 n175__vddio n176__vddio 316.6e-3
rk509 n176__vddio n177__vddio 357.3e-3
rk510 n177__vddio n178__vddio 39.59e-3
rk511 n178__vddio n179__vddio 319.1e-3
rk512 n179__vddio n180__vddio 338.1e-3
rk513 n180__vddio n181__vddio 51.97e-3
rk514 n181__vddio n182__vddio 389.7e-3
rk515 n171__vddio n172__vddio 3.1
rk516 n171__vddio n175__vddio 3.1
rk517 n171__vddio n178__vddio 3.1
rk518 n171__vddio n181__vddio 3.1
rk519 n106__vss n107__vss 54.44e-3
rk520 n107__vss n108__vss 360.5e-3
rk521 n108__vss n109__vss 294.3e-3
rk522 n109__vss n110__vss 42.07e-3
rk523 n110__vss n111__vss 360.5e-3
rk524 n111__vss n112__vss 185e-3
rk525 n112__vss n113__vss 262e-3
rk526 n105__vss n106__vss 3.75
rk527 n105__vss n109__vss 3.75
rk528 n105__vss n112__vss 5.7692
rk532 n353__chipdriverout n354__chipdriverout 12.37e-3
rk533 n354__chipdriverout n355__chipdriverout 360.5e-3
rk534 n355__chipdriverout n356__chipdriverout 223.4e-3
rk535 n356__chipdriverout n357__chipdriverout 114.8e-3
rk536 n357__chipdriverout n358__chipdriverout 360.5e-3
rk537 n358__chipdriverout n359__chipdriverout 239.3e-3
rk538 n359__chipdriverout n360__chipdriverout 118e-3
rk540 n352__chipdriverout n353__chipdriverout 5.7692
rk541 n352__chipdriverout n356__chipdriverout 3.75
rk542 n352__chipdriverout n359__chipdriverout 3.75
rk544 n363__chipdriverout n365__chipdriverout 207.4e-3
rk545 n365__chipdriverout n366__chipdriverout 153.1e-3
rk546 n366__chipdriverout n367__chipdriverout 338.1e-3
rk547 n367__chipdriverout n368__chipdriverout 223.4e-3
rk548 n368__chipdriverout n369__chipdriverout 137.1e-3
rk549 n369__chipdriverout n370__chipdriverout 357.3e-3
rk550 n370__chipdriverout n371__chipdriverout 220.2e-3
rk551 n371__chipdriverout n372__chipdriverout 140.3e-3
rk552 n372__chipdriverout n373__chipdriverout 338.1e-3
rk553 n373__chipdriverout n374__chipdriverout 236.1e-3
rk554 n374__chipdriverout n375__chipdriverout 124.4e-3
rk556 n364__chipdriverout n365__chipdriverout 3.1
rk557 n364__chipdriverout n368__chipdriverout 3.1
rk558 n364__chipdriverout n371__chipdriverout 3.1
rk559 n364__chipdriverout n374__chipdriverout 3.1
rk560 n94__i0__i14__net1 n201__i0__i14__net1 125e-3
rk561 n96__i0__i14__net1 n202__i0__i14__net1 125e-3
rk563 n191__vddio n193__vddio 29.7e-3
rk564 n193__vddio n194__vddio 330.8e-3
rk565 n194__vddio n195__vddio 338.1e-3
rk566 n195__vddio n196__vddio 42.07e-3
rk567 n196__vddio n197__vddio 316.6e-3
rk568 n197__vddio n198__vddio 357.3e-3
rk569 n198__vddio n199__vddio 39.59e-3
rk570 n199__vddio n200__vddio 319.1e-3
rk571 n200__vddio n201__vddio 338.1e-3
rk572 n201__vddio n202__vddio 51.97e-3
rk573 n202__vddio n203__vddio 389.7e-3
rk574 n192__vddio n193__vddio 3.1
rk575 n192__vddio n196__vddio 3.1
rk576 n192__vddio n199__vddio 3.1
rk577 n192__vddio n202__vddio 3.1
rk578 n119__vss n120__vss 54.44e-3
rk579 n120__vss n121__vss 360.5e-3
rk580 n121__vss n122__vss 294.3e-3
rk581 n122__vss n123__vss 42.07e-3
rk582 n123__vss n124__vss 360.5e-3
rk583 n124__vss n125__vss 185e-3
rk584 n125__vss n126__vss 262e-3
rk585 n118__vss n119__vss 3.75
rk586 n118__vss n122__vss 3.75
rk587 n118__vss n125__vss 5.7692
rk588 n98__i0__i14__net1 n213__i0__i14__net1 125e-3
rk589 n100__i0__i14__net1 n214__i0__i14__net1 125e-3
rk591 n392__chipdriverout n393__chipdriverout 12.37e-3
rk592 n393__chipdriverout n394__chipdriverout 360.5e-3
rk593 n394__chipdriverout n395__chipdriverout 223.4e-3
rk594 n395__chipdriverout n396__chipdriverout 114.8e-3
rk595 n396__chipdriverout n397__chipdriverout 360.5e-3
rk596 n397__chipdriverout n398__chipdriverout 239.3e-3
rk597 n398__chipdriverout n399__chipdriverout 118e-3
rk599 n391__chipdriverout n392__chipdriverout 5.7692
rk600 n391__chipdriverout n395__chipdriverout 3.75
rk601 n391__chipdriverout n398__chipdriverout 3.75
rk603 n402__chipdriverout n404__chipdriverout 207.4e-3
rk604 n404__chipdriverout n405__chipdriverout 153.1e-3
rk605 n405__chipdriverout n406__chipdriverout 338.1e-3
rk606 n406__chipdriverout n407__chipdriverout 223.4e-3
rk607 n407__chipdriverout n408__chipdriverout 137.1e-3
rk608 n408__chipdriverout n409__chipdriverout 357.3e-3
rk609 n409__chipdriverout n410__chipdriverout 220.2e-3
rk610 n410__chipdriverout n411__chipdriverout 140.3e-3
rk611 n411__chipdriverout n412__chipdriverout 338.1e-3
rk612 n412__chipdriverout n413__chipdriverout 236.1e-3
rk613 n413__chipdriverout n414__chipdriverout 124.4e-3
rk615 n403__chipdriverout n404__chipdriverout 3.1
rk616 n403__chipdriverout n407__chipdriverout 3.1
rk617 n403__chipdriverout n410__chipdriverout 3.1
rk618 n403__chipdriverout n413__chipdriverout 3.1
rk619 n110__i0__i14__net1 n217__i0__i14__net1 125e-3
rk620 n112__i0__i14__net1 n218__i0__i14__net1 125e-3
rk622 n212__vddio n214__vddio 29.7e-3
rk623 n214__vddio n215__vddio 330.8e-3
rk624 n215__vddio n216__vddio 338.1e-3
rk625 n216__vddio n217__vddio 42.07e-3
rk626 n217__vddio n218__vddio 316.6e-3
rk627 n218__vddio n219__vddio 357.3e-3
rk628 n219__vddio n220__vddio 39.59e-3
rk629 n220__vddio n221__vddio 319.1e-3
rk630 n221__vddio n222__vddio 338.1e-3
rk631 n222__vddio n223__vddio 51.97e-3
rk632 n223__vddio n224__vddio 389.7e-3
rk633 n213__vddio n214__vddio 3.1
rk634 n213__vddio n217__vddio 3.1
rk635 n213__vddio n220__vddio 3.1
rk636 n213__vddio n223__vddio 3.1
rk637 n132__vss n133__vss 54.44e-3
rk638 n133__vss n134__vss 360.5e-3
rk639 n134__vss n135__vss 294.3e-3
rk640 n135__vss n136__vss 42.07e-3
rk641 n136__vss n137__vss 360.5e-3
rk642 n137__vss n138__vss 185e-3
rk643 n138__vss n139__vss 262e-3
rk644 n131__vss n132__vss 3.75
rk645 n131__vss n135__vss 3.75
rk646 n131__vss n138__vss 5.7692
rk647 n114__i0__i14__net1 n229__i0__i14__net1 125e-3
rk648 n116__i0__i14__net1 n230__i0__i14__net1 125e-3
rk650 n431__chipdriverout n432__chipdriverout 12.37e-3
rk651 n432__chipdriverout n433__chipdriverout 360.5e-3
rk652 n433__chipdriverout n434__chipdriverout 223.4e-3
rk653 n434__chipdriverout n435__chipdriverout 114.8e-3
rk654 n435__chipdriverout n436__chipdriverout 360.5e-3
rk655 n436__chipdriverout n437__chipdriverout 239.3e-3
rk656 n437__chipdriverout n438__chipdriverout 118e-3
rk658 n430__chipdriverout n431__chipdriverout 5.7692
rk659 n430__chipdriverout n434__chipdriverout 3.75
rk660 n430__chipdriverout n437__chipdriverout 3.75
rk662 n441__chipdriverout n443__chipdriverout 207.4e-3
rk663 n443__chipdriverout n444__chipdriverout 153.1e-3
rk664 n444__chipdriverout n445__chipdriverout 338.1e-3
rk665 n445__chipdriverout n446__chipdriverout 223.4e-3
rk666 n446__chipdriverout n447__chipdriverout 137.1e-3
rk667 n447__chipdriverout n448__chipdriverout 357.3e-3
rk668 n448__chipdriverout n449__chipdriverout 220.2e-3
rk669 n449__chipdriverout n450__chipdriverout 140.3e-3
rk670 n450__chipdriverout n451__chipdriverout 338.1e-3
rk671 n451__chipdriverout n452__chipdriverout 236.1e-3
rk672 n452__chipdriverout n453__chipdriverout 124.4e-3
rk674 n442__chipdriverout n443__chipdriverout 3.1
rk675 n442__chipdriverout n446__chipdriverout 3.1
rk676 n442__chipdriverout n449__chipdriverout 3.1
rk677 n442__chipdriverout n452__chipdriverout 3.1
rk678 n126__i0__i14__net1 n233__i0__i14__net1 125e-3
rk679 n128__i0__i14__net1 n234__i0__i14__net1 125e-3
rk681 n233__vddio n235__vddio 29.7e-3
rk682 n235__vddio n236__vddio 330.8e-3
rk683 n236__vddio n237__vddio 338.1e-3
rk684 n237__vddio n238__vddio 42.07e-3
rk685 n238__vddio n239__vddio 316.6e-3
rk686 n239__vddio n240__vddio 357.3e-3
rk687 n240__vddio n241__vddio 39.59e-3
rk688 n241__vddio n242__vddio 319.1e-3
rk689 n242__vddio n243__vddio 338.1e-3
rk690 n243__vddio n244__vddio 51.97e-3
rk691 n244__vddio n245__vddio 389.7e-3
rk692 n234__vddio n235__vddio 3.1
rk693 n234__vddio n238__vddio 3.1
rk694 n234__vddio n241__vddio 3.1
rk695 n234__vddio n244__vddio 3.1
rk696 n145__vss n146__vss 54.44e-3
rk697 n146__vss n147__vss 360.5e-3
rk698 n147__vss n148__vss 294.3e-3
rk699 n148__vss n149__vss 42.07e-3
rk700 n149__vss n150__vss 360.5e-3
rk701 n150__vss n151__vss 185e-3
rk702 n151__vss n152__vss 262e-3
rk703 n144__vss n145__vss 3.75
rk704 n144__vss n148__vss 3.75
rk705 n144__vss n151__vss 5.7692
rk706 n130__i0__i14__net1 n245__i0__i14__net1 125e-3
rk707 n132__i0__i14__net1 n246__i0__i14__net1 125e-3
rk709 n479__chipdriverout n496__chipdriverout 207.4e-3
rk710 n496__chipdriverout n480__chipdriverout 153.1e-3
rk711 n480__chipdriverout n483__chipdriverout 338.1e-3
rk712 n483__chipdriverout n497__chipdriverout 223.4e-3
rk713 n497__chipdriverout n484__chipdriverout 137.1e-3
rk714 n484__chipdriverout n487__chipdriverout 357.3e-3
rk715 n487__chipdriverout n498__chipdriverout 220.2e-3
rk716 n498__chipdriverout n488__chipdriverout 140.3e-3
rk717 n488__chipdriverout n491__chipdriverout 338.1e-3
rk718 n491__chipdriverout n499__chipdriverout 236.1e-3
rk719 n499__chipdriverout n492__chipdriverout 124.4e-3
rk721 n495__chipdriverout n496__chipdriverout 3.1
rk722 n495__chipdriverout n497__chipdriverout 3.1
rk723 n495__chipdriverout n498__chipdriverout 3.1
rk724 n495__chipdriverout n499__chipdriverout 3.1
rk726 n503__chipdriverout n468__chipdriverout 12.37e-3
rk727 n468__chipdriverout n471__chipdriverout 360.5e-3
rk728 n471__chipdriverout n504__chipdriverout 223.4e-3
rk729 n504__chipdriverout n472__chipdriverout 114.8e-3
rk730 n472__chipdriverout n475__chipdriverout 360.5e-3
rk731 n475__chipdriverout n505__chipdriverout 239.3e-3
rk732 n505__chipdriverout n476__chipdriverout 118e-3
rk734 n502__chipdriverout n503__chipdriverout 5.7692
rk735 n502__chipdriverout n504__chipdriverout 3.75
rk736 n502__chipdriverout n505__chipdriverout 3.75
rk737 n142__i0__i14__net1 n249__i0__i14__net1 125e-3
rk738 n144__i0__i14__net1 n250__i0__i14__net1 125e-3
rk740 n254__vddio n256__vddio 29.7e-3
rk741 n256__vddio n257__vddio 330.8e-3
rk742 n257__vddio n258__vddio 338.1e-3
rk743 n258__vddio n259__vddio 42.07e-3
rk744 n259__vddio n260__vddio 316.6e-3
rk745 n260__vddio n261__vddio 357.3e-3
rk746 n261__vddio n262__vddio 39.59e-3
rk747 n262__vddio n263__vddio 319.1e-3
rk748 n263__vddio n264__vddio 338.1e-3
rk749 n264__vddio n265__vddio 51.97e-3
rk750 n265__vddio n266__vddio 389.7e-3
rk751 n255__vddio n256__vddio 3.1
rk752 n255__vddio n259__vddio 3.1
rk753 n255__vddio n262__vddio 3.1
rk754 n255__vddio n265__vddio 3.1
rk755 n158__vss n159__vss 54.44e-3
rk756 n159__vss n160__vss 360.5e-3
rk757 n160__vss n161__vss 294.3e-3
rk758 n161__vss n162__vss 42.07e-3
rk759 n162__vss n163__vss 360.5e-3
rk760 n163__vss n164__vss 185e-3
rk761 n164__vss n165__vss 262e-3
rk762 n157__vss n158__vss 3.75
rk763 n157__vss n161__vss 3.75
rk764 n157__vss n164__vss 5.7692
rk765 n146__i0__i14__net1 n261__i0__i14__net1 125e-3
rk766 n148__i0__i14__net1 n262__i0__i14__net1 125e-3
rk768 n518__chipdriverout n535__chipdriverout 207.4e-3
rk769 n535__chipdriverout n519__chipdriverout 153.1e-3
rk770 n519__chipdriverout n522__chipdriverout 338.1e-3
rk771 n522__chipdriverout n536__chipdriverout 223.4e-3
rk772 n536__chipdriverout n523__chipdriverout 137.1e-3
rk773 n523__chipdriverout n526__chipdriverout 357.3e-3
rk774 n526__chipdriverout n537__chipdriverout 220.2e-3
rk775 n537__chipdriverout n527__chipdriverout 140.3e-3
rk776 n527__chipdriverout n530__chipdriverout 338.1e-3
rk777 n530__chipdriverout n538__chipdriverout 236.1e-3
rk778 n538__chipdriverout n531__chipdriverout 124.4e-3
rk780 n534__chipdriverout n535__chipdriverout 3.1
rk781 n534__chipdriverout n536__chipdriverout 3.1
rk782 n534__chipdriverout n537__chipdriverout 3.1
rk783 n534__chipdriverout n538__chipdriverout 3.1
rk785 n542__chipdriverout n507__chipdriverout 12.37e-3
rk786 n507__chipdriverout n510__chipdriverout 360.5e-3
rk787 n510__chipdriverout n543__chipdriverout 223.4e-3
rk788 n543__chipdriverout n511__chipdriverout 114.8e-3
rk789 n511__chipdriverout n514__chipdriverout 360.5e-3
rk790 n514__chipdriverout n544__chipdriverout 239.3e-3
rk791 n544__chipdriverout n515__chipdriverout 118e-3
rk793 n541__chipdriverout n542__chipdriverout 5.7692
rk794 n541__chipdriverout n543__chipdriverout 3.75
rk795 n541__chipdriverout n544__chipdriverout 3.75
rk796 n158__i0__i14__net1 n265__i0__i14__net1 125e-3
rk797 n160__i0__i14__net1 n266__i0__i14__net1 125e-3
rk799 n275__vddio n277__vddio 29.7e-3
rk800 n277__vddio n278__vddio 330.8e-3
rk801 n278__vddio n279__vddio 338.1e-3
rk802 n279__vddio n280__vddio 42.07e-3
rk803 n280__vddio n281__vddio 316.6e-3
rk804 n281__vddio n282__vddio 357.3e-3
rk805 n282__vddio n283__vddio 39.59e-3
rk806 n283__vddio n284__vddio 319.1e-3
rk807 n284__vddio n285__vddio 338.1e-3
rk808 n285__vddio n286__vddio 51.97e-3
rk809 n286__vddio n287__vddio 389.7e-3
rk810 n276__vddio n277__vddio 3.1
rk811 n276__vddio n280__vddio 3.1
rk812 n276__vddio n283__vddio 3.1
rk813 n276__vddio n286__vddio 3.1
rk814 n171__vss n172__vss 54.44e-3
rk815 n172__vss n173__vss 360.5e-3
rk816 n173__vss n174__vss 294.3e-3
rk817 n174__vss n175__vss 42.07e-3
rk818 n175__vss n176__vss 360.5e-3
rk819 n176__vss n177__vss 185e-3
rk820 n177__vss n178__vss 262e-3
rk821 n170__vss n171__vss 3.75
rk822 n170__vss n174__vss 3.75
rk823 n170__vss n177__vss 5.7692
rk827 n557__chipdriverout n574__chipdriverout 207.4e-3
rk828 n574__chipdriverout n558__chipdriverout 153.1e-3
rk829 n558__chipdriverout n561__chipdriverout 338.1e-3
rk830 n561__chipdriverout n575__chipdriverout 223.4e-3
rk831 n575__chipdriverout n562__chipdriverout 137.1e-3
rk832 n562__chipdriverout n565__chipdriverout 357.3e-3
rk833 n565__chipdriverout n576__chipdriverout 220.2e-3
rk834 n576__chipdriverout n566__chipdriverout 140.3e-3
rk835 n566__chipdriverout n569__chipdriverout 338.1e-3
rk836 n569__chipdriverout n577__chipdriverout 236.1e-3
rk837 n577__chipdriverout n570__chipdriverout 124.4e-3
rk839 n573__chipdriverout n574__chipdriverout 3.1
rk840 n573__chipdriverout n575__chipdriverout 3.1
rk841 n573__chipdriverout n576__chipdriverout 3.1
rk842 n573__chipdriverout n577__chipdriverout 3.1
rk844 n581__chipdriverout n546__chipdriverout 12.37e-3
rk845 n546__chipdriverout n549__chipdriverout 360.5e-3
rk846 n549__chipdriverout n582__chipdriverout 223.4e-3
rk847 n582__chipdriverout n550__chipdriverout 114.8e-3
rk848 n550__chipdriverout n553__chipdriverout 360.5e-3
rk849 n553__chipdriverout n583__chipdriverout 239.3e-3
rk850 n583__chipdriverout n554__chipdriverout 118e-3
rk852 n580__chipdriverout n581__chipdriverout 5.7692
rk853 n580__chipdriverout n582__chipdriverout 3.75
rk854 n580__chipdriverout n583__chipdriverout 3.75
rk855 n174__i0__i14__net1 n281__i0__i14__net1 125e-3
rk856 n176__i0__i14__net1 n282__i0__i14__net1 125e-3
rk858 n296__vddio n298__vddio 29.7e-3
rk859 n298__vddio n299__vddio 330.8e-3
rk860 n299__vddio n300__vddio 338.1e-3
rk861 n300__vddio n301__vddio 42.07e-3
rk862 n301__vddio n302__vddio 316.6e-3
rk863 n302__vddio n303__vddio 357.3e-3
rk864 n303__vddio n304__vddio 39.59e-3
rk865 n304__vddio n305__vddio 319.1e-3
rk866 n305__vddio n306__vddio 338.1e-3
rk867 n306__vddio n307__vddio 51.97e-3
rk868 n307__vddio n308__vddio 389.7e-3
rk869 n297__vddio n298__vddio 3.1
rk870 n297__vddio n301__vddio 3.1
rk871 n297__vddio n304__vddio 3.1
rk872 n297__vddio n307__vddio 3.1
rk873 n184__vss n185__vss 54.44e-3
rk874 n185__vss n186__vss 360.5e-3
rk875 n186__vss n187__vss 294.3e-3
rk876 n187__vss n188__vss 42.07e-3
rk877 n188__vss n189__vss 360.5e-3
rk878 n189__vss n190__vss 185e-3
rk879 n190__vss n191__vss 262e-3
rk880 n183__vss n184__vss 3.75
rk881 n183__vss n187__vss 3.75
rk882 n183__vss n190__vss 5.7692
rk886 n596__chipdriverout n613__chipdriverout 207.4e-3
rk887 n613__chipdriverout n597__chipdriverout 153.1e-3
rk888 n597__chipdriverout n600__chipdriverout 338.1e-3
rk889 n600__chipdriverout n614__chipdriverout 223.4e-3
rk890 n614__chipdriverout n601__chipdriverout 137.1e-3
rk891 n601__chipdriverout n604__chipdriverout 357.3e-3
rk892 n604__chipdriverout n615__chipdriverout 220.2e-3
rk893 n615__chipdriverout n605__chipdriverout 140.3e-3
rk894 n605__chipdriverout n608__chipdriverout 338.1e-3
rk895 n608__chipdriverout n616__chipdriverout 236.1e-3
rk896 n616__chipdriverout n609__chipdriverout 124.4e-3
rk898 n612__chipdriverout n613__chipdriverout 3.1
rk899 n612__chipdriverout n614__chipdriverout 3.1
rk900 n612__chipdriverout n615__chipdriverout 3.1
rk901 n612__chipdriverout n616__chipdriverout 3.1
rk903 n620__chipdriverout n585__chipdriverout 12.37e-3
rk904 n585__chipdriverout n588__chipdriverout 360.5e-3
rk905 n588__chipdriverout n621__chipdriverout 223.4e-3
rk906 n621__chipdriverout n589__chipdriverout 114.8e-3
rk907 n589__chipdriverout n592__chipdriverout 360.5e-3
rk908 n592__chipdriverout n622__chipdriverout 239.3e-3
rk909 n622__chipdriverout n593__chipdriverout 118e-3
rk911 n619__chipdriverout n620__chipdriverout 5.7692
rk912 n619__chipdriverout n621__chipdriverout 3.75
rk913 n619__chipdriverout n622__chipdriverout 3.75
rk914 n190__i0__i14__net1 n301__i0__i14__net1 125e-3
rk915 n192__i0__i14__net1 n302__i0__i14__net1 125e-3
rk917 n317__vddio n319__vddio 29.7e-3
rk918 n319__vddio n320__vddio 330.8e-3
rk919 n320__vddio n321__vddio 338.1e-3
rk920 n321__vddio n322__vddio 42.07e-3
rk921 n322__vddio n323__vddio 316.6e-3
rk922 n323__vddio n324__vddio 357.3e-3
rk923 n324__vddio n325__vddio 39.59e-3
rk924 n325__vddio n326__vddio 319.1e-3
rk925 n326__vddio n327__vddio 338.1e-3
rk926 n327__vddio n328__vddio 51.97e-3
rk927 n328__vddio n329__vddio 389.7e-3
rk928 n318__vddio n319__vddio 3.1
rk929 n318__vddio n322__vddio 3.1
rk930 n318__vddio n325__vddio 3.1
rk931 n318__vddio n328__vddio 3.1
rk932 n197__vss n198__vss 54.44e-3
rk933 n198__vss n199__vss 360.5e-3
rk934 n199__vss n200__vss 294.3e-3
rk935 n200__vss n201__vss 42.07e-3
rk936 n201__vss n202__vss 360.5e-3
rk937 n202__vss n203__vss 185e-3
rk938 n203__vss n204__vss 262e-3
rk939 n196__vss n197__vss 3.75
rk940 n196__vss n200__vss 3.75
rk941 n196__vss n203__vss 5.7692
rk945 n635__chipdriverout n652__chipdriverout 207.4e-3
rk946 n652__chipdriverout n636__chipdriverout 153.1e-3
rk947 n636__chipdriverout n639__chipdriverout 338.1e-3
rk948 n639__chipdriverout n653__chipdriverout 223.4e-3
rk949 n653__chipdriverout n640__chipdriverout 137.1e-3
rk950 n640__chipdriverout n643__chipdriverout 357.3e-3
rk951 n643__chipdriverout n654__chipdriverout 220.2e-3
rk952 n654__chipdriverout n644__chipdriverout 140.3e-3
rk953 n644__chipdriverout n647__chipdriverout 338.1e-3
rk954 n647__chipdriverout n655__chipdriverout 236.1e-3
rk955 n655__chipdriverout n648__chipdriverout 124.4e-3
rk957 n651__chipdriverout n652__chipdriverout 3.1
rk958 n651__chipdriverout n653__chipdriverout 3.1
rk959 n651__chipdriverout n654__chipdriverout 3.1
rk960 n651__chipdriverout n655__chipdriverout 3.1
rk962 n659__chipdriverout n624__chipdriverout 12.37e-3
rk963 n624__chipdriverout n627__chipdriverout 360.5e-3
rk964 n627__chipdriverout n660__chipdriverout 223.4e-3
rk965 n660__chipdriverout n628__chipdriverout 114.8e-3
rk966 n628__chipdriverout n631__chipdriverout 360.5e-3
rk967 n631__chipdriverout n661__chipdriverout 239.3e-3
rk968 n661__chipdriverout n632__chipdriverout 118e-3
rk970 n658__chipdriverout n659__chipdriverout 5.7692
rk971 n658__chipdriverout n660__chipdriverout 3.75
rk972 n658__chipdriverout n661__chipdriverout 3.75
rk973 n206__i0__i14__net1 n317__i0__i14__net1 125e-3
rk974 n208__i0__i14__net1 n318__i0__i14__net1 125e-3
rk976 n338__vddio n340__vddio 29.7e-3
rk977 n340__vddio n341__vddio 330.8e-3
rk978 n341__vddio n342__vddio 338.1e-3
rk979 n342__vddio n343__vddio 42.07e-3
rk980 n343__vddio n344__vddio 316.6e-3
rk981 n344__vddio n345__vddio 357.3e-3
rk982 n345__vddio n346__vddio 39.59e-3
rk983 n346__vddio n347__vddio 319.1e-3
rk984 n347__vddio n348__vddio 338.1e-3
rk985 n348__vddio n349__vddio 51.97e-3
rk986 n349__vddio n350__vddio 389.7e-3
rk987 n339__vddio n340__vddio 3.1
rk988 n339__vddio n343__vddio 3.1
rk989 n339__vddio n346__vddio 3.1
rk990 n339__vddio n349__vddio 3.1
rk991 n210__vss n211__vss 54.44e-3
rk992 n211__vss n212__vss 360.5e-3
rk993 n212__vss n213__vss 294.3e-3
rk994 n213__vss n214__vss 42.07e-3
rk995 n214__vss n215__vss 360.5e-3
rk996 n215__vss n216__vss 185e-3
rk997 n216__vss n217__vss 262e-3
rk998 n209__vss n210__vss 3.75
rk999 n209__vss n213__vss 3.75
rk1000 n209__vss n216__vss 5.7692
rk1004 n674__chipdriverout n691__chipdriverout 207.4e-3
rk1005 n691__chipdriverout n675__chipdriverout 153.1e-3
rk1006 n675__chipdriverout n678__chipdriverout 338.1e-3
rk1007 n678__chipdriverout n692__chipdriverout 223.4e-3
rk1008 n692__chipdriverout n679__chipdriverout 137.1e-3
rk1009 n679__chipdriverout n682__chipdriverout 357.3e-3
rk1010 n682__chipdriverout n693__chipdriverout 220.2e-3
rk1011 n693__chipdriverout n683__chipdriverout 140.3e-3
rk1012 n683__chipdriverout n686__chipdriverout 338.1e-3
rk1013 n686__chipdriverout n694__chipdriverout 236.1e-3
rk1014 n694__chipdriverout n687__chipdriverout 124.4e-3
rk1016 n690__chipdriverout n691__chipdriverout 3.1
rk1017 n690__chipdriverout n692__chipdriverout 3.1
rk1018 n690__chipdriverout n693__chipdriverout 3.1
rk1019 n690__chipdriverout n694__chipdriverout 3.1
rk1021 n698__chipdriverout n663__chipdriverout 12.37e-3
rk1022 n663__chipdriverout n666__chipdriverout 360.5e-3
rk1023 n666__chipdriverout n699__chipdriverout 223.4e-3
rk1024 n699__chipdriverout n667__chipdriverout 114.8e-3
rk1025 n667__chipdriverout n670__chipdriverout 360.5e-3
rk1026 n670__chipdriverout n700__chipdriverout 239.3e-3
rk1027 n700__chipdriverout n671__chipdriverout 118e-3
rk1029 n697__chipdriverout n698__chipdriverout 5.7692
rk1030 n697__chipdriverout n699__chipdriverout 3.75
rk1031 n697__chipdriverout n700__chipdriverout 3.75
rk1032 n222__i0__i14__net1 n333__i0__i14__net1 125e-3
rk1033 n224__i0__i14__net1 n334__i0__i14__net1 125e-3
rk1035 n359__vddio n361__vddio 29.7e-3
rk1036 n361__vddio n362__vddio 330.8e-3
rk1037 n362__vddio n363__vddio 338.1e-3
rk1038 n363__vddio n364__vddio 42.07e-3
rk1039 n364__vddio n365__vddio 316.6e-3
rk1040 n365__vddio n366__vddio 357.3e-3
rk1041 n366__vddio n367__vddio 39.59e-3
rk1042 n367__vddio n368__vddio 319.1e-3
rk1043 n368__vddio n369__vddio 338.1e-3
rk1044 n369__vddio n370__vddio 51.97e-3
rk1045 n370__vddio n371__vddio 389.7e-3
rk1046 n360__vddio n361__vddio 3.1
rk1047 n360__vddio n364__vddio 3.1
rk1048 n360__vddio n367__vddio 3.1
rk1049 n360__vddio n370__vddio 3.1
rk1050 n223__vss n224__vss 54.44e-3
rk1051 n224__vss n225__vss 360.5e-3
rk1052 n225__vss n226__vss 294.3e-3
rk1053 n226__vss n227__vss 42.07e-3
rk1054 n227__vss n228__vss 360.5e-3
rk1055 n228__vss n229__vss 185e-3
rk1056 n229__vss n230__vss 262e-3
rk1057 n222__vss n223__vss 3.75
rk1058 n222__vss n226__vss 3.75
rk1059 n222__vss n229__vss 5.7692
rk1063 n713__chipdriverout n730__chipdriverout 207.4e-3
rk1064 n730__chipdriverout n714__chipdriverout 153.1e-3
rk1065 n714__chipdriverout n717__chipdriverout 338.1e-3
rk1066 n717__chipdriverout n731__chipdriverout 223.4e-3
rk1067 n731__chipdriverout n718__chipdriverout 137.1e-3
rk1068 n718__chipdriverout n721__chipdriverout 357.3e-3
rk1069 n721__chipdriverout n732__chipdriverout 220.2e-3
rk1070 n732__chipdriverout n722__chipdriverout 140.3e-3
rk1071 n722__chipdriverout n725__chipdriverout 338.1e-3
rk1072 n725__chipdriverout n733__chipdriverout 236.1e-3
rk1073 n733__chipdriverout n726__chipdriverout 124.4e-3
rk1075 n729__chipdriverout n730__chipdriverout 3.1
rk1076 n729__chipdriverout n731__chipdriverout 3.1
rk1077 n729__chipdriverout n732__chipdriverout 3.1
rk1078 n729__chipdriverout n733__chipdriverout 3.1
rk1080 n737__chipdriverout n702__chipdriverout 12.37e-3
rk1081 n702__chipdriverout n705__chipdriverout 360.5e-3
rk1082 n705__chipdriverout n738__chipdriverout 223.4e-3
rk1083 n738__chipdriverout n706__chipdriverout 114.8e-3
rk1084 n706__chipdriverout n709__chipdriverout 360.5e-3
rk1085 n709__chipdriverout n739__chipdriverout 239.3e-3
rk1086 n739__chipdriverout n710__chipdriverout 118e-3
rk1088 n736__chipdriverout n737__chipdriverout 5.7692
rk1089 n736__chipdriverout n738__chipdriverout 3.75
rk1090 n736__chipdriverout n739__chipdriverout 3.75
rk1091 n238__i0__i14__net1 n349__i0__i14__net1 125e-3
rk1092 n240__i0__i14__net1 n350__i0__i14__net1 125e-3
rk1094 n380__vddio n382__vddio 29.7e-3
rk1095 n382__vddio n383__vddio 330.8e-3
rk1096 n383__vddio n384__vddio 338.1e-3
rk1097 n384__vddio n385__vddio 42.07e-3
rk1098 n385__vddio n386__vddio 316.6e-3
rk1099 n386__vddio n387__vddio 357.3e-3
rk1100 n387__vddio n388__vddio 39.59e-3
rk1101 n388__vddio n389__vddio 319.1e-3
rk1102 n389__vddio n390__vddio 338.1e-3
rk1103 n390__vddio n391__vddio 51.97e-3
rk1104 n391__vddio n392__vddio 389.7e-3
rk1105 n381__vddio n382__vddio 3.1
rk1106 n381__vddio n385__vddio 3.1
rk1107 n381__vddio n388__vddio 3.1
rk1108 n381__vddio n391__vddio 3.1
rk1109 n236__vss n237__vss 54.44e-3
rk1110 n237__vss n238__vss 360.5e-3
rk1111 n238__vss n239__vss 294.3e-3
rk1112 n239__vss n240__vss 42.07e-3
rk1113 n240__vss n241__vss 360.5e-3
rk1114 n241__vss n242__vss 185e-3
rk1115 n242__vss n243__vss 262e-3
rk1116 n235__vss n236__vss 3.75
rk1117 n235__vss n239__vss 3.75
rk1118 n235__vss n242__vss 5.7692
rk1122 n742__chipdriverout n744__chipdriverout 207.4e-3
rk1123 n744__chipdriverout n745__chipdriverout 153.1e-3
rk1124 n745__chipdriverout n746__chipdriverout 338.1e-3
rk1125 n746__chipdriverout n747__chipdriverout 223.4e-3
rk1126 n747__chipdriverout n748__chipdriverout 137.1e-3
rk1127 n748__chipdriverout n749__chipdriverout 357.3e-3
rk1128 n749__chipdriverout n750__chipdriverout 220.2e-3
rk1129 n750__chipdriverout n751__chipdriverout 140.3e-3
rk1130 n751__chipdriverout n752__chipdriverout 338.1e-3
rk1131 n752__chipdriverout n753__chipdriverout 236.1e-3
rk1132 n753__chipdriverout n754__chipdriverout 124.4e-3
rk1134 n743__chipdriverout n744__chipdriverout 3.1
rk1135 n743__chipdriverout n747__chipdriverout 3.1
rk1136 n743__chipdriverout n750__chipdriverout 3.1
rk1137 n743__chipdriverout n753__chipdriverout 3.1
rk1139 n758__chipdriverout n759__chipdriverout 12.37e-3
rk1140 n759__chipdriverout n760__chipdriverout 360.5e-3
rk1141 n760__chipdriverout n761__chipdriverout 223.4e-3
rk1142 n761__chipdriverout n762__chipdriverout 114.8e-3
rk1143 n762__chipdriverout n763__chipdriverout 360.5e-3
rk1144 n763__chipdriverout n764__chipdriverout 239.3e-3
rk1145 n764__chipdriverout n765__chipdriverout 118e-3
rk1147 n757__chipdriverout n758__chipdriverout 5.7692
rk1148 n757__chipdriverout n761__chipdriverout 3.75
rk1149 n757__chipdriverout n764__chipdriverout 3.75
rk1150 n254__i0__i14__net1 n365__i0__i14__net1 125e-3
rk1151 n256__i0__i14__net1 n366__i0__i14__net1 125e-3
rk1153 n401__vddio n403__vddio 29.7e-3
rk1154 n403__vddio n404__vddio 330.8e-3
rk1155 n404__vddio n405__vddio 338.1e-3
rk1156 n405__vddio n406__vddio 42.07e-3
rk1157 n406__vddio n407__vddio 316.6e-3
rk1158 n407__vddio n408__vddio 357.3e-3
rk1159 n408__vddio n409__vddio 39.59e-3
rk1160 n409__vddio n410__vddio 319.1e-3
rk1161 n410__vddio n411__vddio 338.1e-3
rk1162 n411__vddio n412__vddio 51.97e-3
rk1163 n412__vddio n413__vddio 389.7e-3
rk1164 n402__vddio n403__vddio 3.1
rk1165 n402__vddio n406__vddio 3.1
rk1166 n402__vddio n409__vddio 3.1
rk1167 n402__vddio n412__vddio 3.1
rk1168 n257__vss n255__vss 54.44e-3
rk1169 n255__vss n252__vss 360.5e-3
rk1170 n252__vss n258__vss 294.3e-3
rk1171 n258__vss n251__vss 42.07e-3
rk1172 n251__vss n248__vss 360.5e-3
rk1173 n248__vss n259__vss 185e-3
rk1174 n259__vss n260__vss 263.8e-3
rk1175 n256__vss n257__vss 3.75
rk1176 n256__vss n258__vss 3.75
rk1177 n256__vss n259__vss 5.7692
rk1181 n782__chipdriverout n783__chipdriverout 12.37e-3
rk1182 n783__chipdriverout n784__chipdriverout 360.5e-3
rk1183 n784__chipdriverout n785__chipdriverout 223.4e-3
rk1184 n785__chipdriverout n786__chipdriverout 114.8e-3
rk1185 n786__chipdriverout n787__chipdriverout 360.5e-3
rk1186 n787__chipdriverout n788__chipdriverout 239.3e-3
rk1187 n788__chipdriverout n789__chipdriverout 118e-3
rk1189 n781__chipdriverout n782__chipdriverout 5.7692
rk1190 n781__chipdriverout n785__chipdriverout 3.75
rk1191 n781__chipdriverout n788__chipdriverout 3.75
rk1193 n792__chipdriverout n794__chipdriverout 207.4e-3
rk1194 n794__chipdriverout n795__chipdriverout 153.1e-3
rk1195 n795__chipdriverout n796__chipdriverout 338.1e-3
rk1196 n796__chipdriverout n797__chipdriverout 223.4e-3
rk1197 n797__chipdriverout n798__chipdriverout 137.1e-3
rk1198 n798__chipdriverout n799__chipdriverout 357.3e-3
rk1199 n799__chipdriverout n800__chipdriverout 220.2e-3
rk1200 n800__chipdriverout n801__chipdriverout 140.3e-3
rk1201 n801__chipdriverout n802__chipdriverout 338.1e-3
rk1202 n802__chipdriverout n803__chipdriverout 236.1e-3
rk1203 n803__chipdriverout n804__chipdriverout 124.4e-3
rk1205 n793__chipdriverout n794__chipdriverout 3.1
rk1206 n793__chipdriverout n797__chipdriverout 3.1
rk1207 n793__chipdriverout n800__chipdriverout 3.1
rk1208 n793__chipdriverout n803__chipdriverout 3.1
rk1209 n270__i0__i14__net1 n381__i0__i14__net1 125e-3
rk1210 n272__i0__i14__net1 n382__i0__i14__net1 125e-3
rk1212 n422__vddio n424__vddio 29.7e-3
rk1213 n424__vddio n425__vddio 330.8e-3
rk1214 n425__vddio n426__vddio 338.1e-3
rk1215 n426__vddio n427__vddio 42.07e-3
rk1216 n427__vddio n428__vddio 316.6e-3
rk1217 n428__vddio n429__vddio 357.3e-3
rk1218 n429__vddio n430__vddio 39.59e-3
rk1219 n430__vddio n431__vddio 319.1e-3
rk1220 n431__vddio n432__vddio 338.1e-3
rk1221 n432__vddio n433__vddio 51.97e-3
rk1222 n433__vddio n434__vddio 389.7e-3
rk1223 n423__vddio n424__vddio 3.1
rk1224 n423__vddio n427__vddio 3.1
rk1225 n423__vddio n430__vddio 3.1
rk1226 n423__vddio n433__vddio 3.1
rk1227 n270__vss n268__vss 54.44e-3
rk1228 n268__vss n265__vss 360.5e-3
rk1229 n265__vss n271__vss 294.3e-3
rk1230 n271__vss n264__vss 42.07e-3
rk1231 n264__vss n261__vss 360.5e-3
rk1232 n261__vss n272__vss 185e-3
rk1233 n272__vss n273__vss 262e-3
rk1234 n269__vss n270__vss 3.75
rk1235 n269__vss n271__vss 3.75
rk1236 n269__vss n272__vss 5.7692
rk1240 n821__chipdriverout n822__chipdriverout 12.37e-3
rk1241 n822__chipdriverout n823__chipdriverout 360.5e-3
rk1242 n823__chipdriverout n824__chipdriverout 223.4e-3
rk1243 n824__chipdriverout n825__chipdriverout 114.8e-3
rk1244 n825__chipdriverout n826__chipdriverout 360.5e-3
rk1245 n826__chipdriverout n827__chipdriverout 239.3e-3
rk1246 n827__chipdriverout n828__chipdriverout 118e-3
rk1248 n820__chipdriverout n821__chipdriverout 5.7692
rk1249 n820__chipdriverout n824__chipdriverout 3.75
rk1250 n820__chipdriverout n827__chipdriverout 3.75
rk1252 n831__chipdriverout n833__chipdriverout 207.4e-3
rk1253 n833__chipdriverout n834__chipdriverout 153.1e-3
rk1254 n834__chipdriverout n835__chipdriverout 338.1e-3
rk1255 n835__chipdriverout n836__chipdriverout 223.4e-3
rk1256 n836__chipdriverout n837__chipdriverout 137.1e-3
rk1257 n837__chipdriverout n838__chipdriverout 357.3e-3
rk1258 n838__chipdriverout n839__chipdriverout 220.2e-3
rk1259 n839__chipdriverout n840__chipdriverout 140.3e-3
rk1260 n840__chipdriverout n841__chipdriverout 338.1e-3
rk1261 n841__chipdriverout n842__chipdriverout 236.1e-3
rk1262 n842__chipdriverout n843__chipdriverout 124.4e-3
rk1264 n832__chipdriverout n833__chipdriverout 3.1
rk1265 n832__chipdriverout n836__chipdriverout 3.1
rk1266 n832__chipdriverout n839__chipdriverout 3.1
rk1267 n832__chipdriverout n842__chipdriverout 3.1
rk1268 n286__i0__i14__net1 n397__i0__i14__net1 125e-3
rk1269 n288__i0__i14__net1 n398__i0__i14__net1 125e-3
rk1271 n443__vddio n445__vddio 29.7e-3
rk1272 n445__vddio n446__vddio 330.8e-3
rk1273 n446__vddio n447__vddio 338.1e-3
rk1274 n447__vddio n448__vddio 42.07e-3
rk1275 n448__vddio n449__vddio 316.6e-3
rk1276 n449__vddio n450__vddio 357.3e-3
rk1277 n450__vddio n451__vddio 39.59e-3
rk1278 n451__vddio n452__vddio 319.1e-3
rk1279 n452__vddio n453__vddio 338.1e-3
rk1280 n453__vddio n454__vddio 51.97e-3
rk1281 n454__vddio n455__vddio 389.7e-3
rk1282 n444__vddio n445__vddio 3.1
rk1283 n444__vddio n448__vddio 3.1
rk1284 n444__vddio n451__vddio 3.1
rk1285 n444__vddio n454__vddio 3.1
rk1286 n283__vss n281__vss 54.44e-3
rk1287 n281__vss n278__vss 360.5e-3
rk1288 n278__vss n284__vss 294.3e-3
rk1289 n284__vss n277__vss 42.07e-3
rk1290 n277__vss n274__vss 360.5e-3
rk1291 n274__vss n285__vss 185e-3
rk1292 n285__vss n286__vss 262e-3
rk1293 n282__vss n283__vss 3.75
rk1294 n282__vss n284__vss 3.75
rk1295 n282__vss n285__vss 5.7692
rk1299 n859__chipdriverout n876__chipdriverout 207.4e-3
rk1300 n876__chipdriverout n860__chipdriverout 153.1e-3
rk1301 n860__chipdriverout n863__chipdriverout 338.1e-3
rk1302 n863__chipdriverout n877__chipdriverout 223.4e-3
rk1303 n877__chipdriverout n864__chipdriverout 137.1e-3
rk1304 n864__chipdriverout n867__chipdriverout 357.3e-3
rk1305 n867__chipdriverout n878__chipdriverout 220.2e-3
rk1306 n878__chipdriverout n868__chipdriverout 140.3e-3
rk1307 n868__chipdriverout n871__chipdriverout 338.1e-3
rk1308 n871__chipdriverout n879__chipdriverout 236.1e-3
rk1309 n879__chipdriverout n872__chipdriverout 124.4e-3
rk1311 n875__chipdriverout n876__chipdriverout 3.1
rk1312 n875__chipdriverout n877__chipdriverout 3.1
rk1313 n875__chipdriverout n878__chipdriverout 3.1
rk1314 n875__chipdriverout n879__chipdriverout 3.1
rk1316 n883__chipdriverout n884__chipdriverout 12.37e-3
rk1317 n884__chipdriverout n885__chipdriverout 360.5e-3
rk1318 n885__chipdriverout n886__chipdriverout 223.4e-3
rk1319 n886__chipdriverout n887__chipdriverout 114.8e-3
rk1320 n887__chipdriverout n888__chipdriverout 360.5e-3
rk1321 n888__chipdriverout n889__chipdriverout 239.3e-3
rk1322 n889__chipdriverout n890__chipdriverout 118e-3
rk1324 n882__chipdriverout n883__chipdriverout 5.7692
rk1325 n882__chipdriverout n886__chipdriverout 3.75
rk1326 n882__chipdriverout n889__chipdriverout 3.75
rk1327 n298__i0__i14__net1 n413__i0__i14__net1 125e-3
rk1328 n300__i0__i14__net1 n414__i0__i14__net1 125e-3
rk1330 n464__vddio n466__vddio 29.7e-3
rk1331 n466__vddio n467__vddio 330.8e-3
rk1332 n467__vddio n468__vddio 338.1e-3
rk1333 n468__vddio n469__vddio 42.07e-3
rk1334 n469__vddio n470__vddio 316.6e-3
rk1335 n470__vddio n471__vddio 357.3e-3
rk1336 n471__vddio n472__vddio 39.59e-3
rk1337 n472__vddio n473__vddio 319.1e-3
rk1338 n473__vddio n474__vddio 338.1e-3
rk1339 n474__vddio n475__vddio 51.97e-3
rk1340 n475__vddio n476__vddio 389.7e-3
rk1341 n465__vddio n466__vddio 3.1
rk1342 n465__vddio n469__vddio 3.1
rk1343 n465__vddio n472__vddio 3.1
rk1344 n465__vddio n475__vddio 3.1
rk1345 n296__vss n290__vss 54.44e-3
rk1346 n290__vss n287__vss 360.5e-3
rk1347 n287__vss n297__vss 294.3e-3
rk1348 n297__vss n294__vss 42.07e-3
rk1349 n294__vss n291__vss 360.5e-3
rk1350 n291__vss n298__vss 185e-3
rk1351 n298__vss n299__vss 262e-3
rk1352 n295__vss n296__vss 3.75
rk1353 n295__vss n297__vss 3.75
rk1354 n295__vss n298__vss 5.7692
rk1358 n925__chipdriverout n897__chipdriverout 12.37e-3
rk1359 n897__chipdriverout n900__chipdriverout 360.5e-3
rk1360 n900__chipdriverout n926__chipdriverout 223.4e-3
rk1361 n926__chipdriverout n901__chipdriverout 114.8e-3
rk1362 n901__chipdriverout n904__chipdriverout 360.5e-3
rk1363 n904__chipdriverout n927__chipdriverout 239.3e-3
rk1364 n927__chipdriverout n905__chipdriverout 118e-3
rk1366 n924__chipdriverout n925__chipdriverout 5.7692
rk1367 n924__chipdriverout n926__chipdriverout 3.75
rk1368 n924__chipdriverout n927__chipdriverout 3.75
rk1370 n908__chipdriverout n931__chipdriverout 207.4e-3
rk1371 n931__chipdriverout n909__chipdriverout 153.1e-3
rk1372 n909__chipdriverout n912__chipdriverout 338.1e-3
rk1373 n912__chipdriverout n932__chipdriverout 223.4e-3
rk1374 n932__chipdriverout n913__chipdriverout 137.1e-3
rk1375 n913__chipdriverout n916__chipdriverout 357.3e-3
rk1376 n916__chipdriverout n933__chipdriverout 220.2e-3
rk1377 n933__chipdriverout n917__chipdriverout 140.3e-3
rk1378 n917__chipdriverout n920__chipdriverout 338.1e-3
rk1379 n920__chipdriverout n934__chipdriverout 236.1e-3
rk1380 n934__chipdriverout n921__chipdriverout 124.4e-3
rk1382 n930__chipdriverout n931__chipdriverout 3.1
rk1383 n930__chipdriverout n932__chipdriverout 3.1
rk1384 n930__chipdriverout n933__chipdriverout 3.1
rk1385 n930__chipdriverout n934__chipdriverout 3.1
rk1386 n314__i0__i14__net1 n425__i0__i14__net1 125e-3
rk1387 n316__i0__i14__net1 n426__i0__i14__net1 125e-3
rk1389 n485__vddio n487__vddio 29.7e-3
rk1390 n487__vddio n488__vddio 330.8e-3
rk1391 n488__vddio n489__vddio 338.1e-3
rk1392 n489__vddio n490__vddio 42.07e-3
rk1393 n490__vddio n491__vddio 316.6e-3
rk1394 n491__vddio n492__vddio 357.3e-3
rk1395 n492__vddio n493__vddio 39.59e-3
rk1396 n493__vddio n494__vddio 319.1e-3
rk1397 n494__vddio n495__vddio 338.1e-3
rk1398 n495__vddio n496__vddio 51.97e-3
rk1399 n496__vddio n497__vddio 389.7e-3
rk1400 n486__vddio n487__vddio 3.1
rk1401 n486__vddio n490__vddio 3.1
rk1402 n486__vddio n493__vddio 3.1
rk1403 n486__vddio n496__vddio 3.1
rk1404 n309__vss n307__vss 54.44e-3
rk1405 n307__vss n304__vss 364.1e-3
rk1406 n304__vss n310__vss 299.7e-3
rk1407 n310__vss n303__vss 42.07e-3
rk1408 n303__vss n300__vss 364.1e-3
rk1409 n300__vss n311__vss 186.8e-3
rk1410 n311__vss n312__vss 262e-3
rk1411 n308__vss n309__vss 3.75
rk1412 n308__vss n310__vss 3.75
rk1413 n308__vss n311__vss 5.7692
rk1414 n325__i0__i14__net1 n437__i0__i14__net1 125e-3
rk1415 n327__i0__i14__net1 n438__i0__i14__net1 125e-3
rk1417 n938__chipdriverout n939__chipdriverout 12.37e-3
rk1418 n939__chipdriverout n940__chipdriverout 360.5e-3
rk1419 n940__chipdriverout n941__chipdriverout 223.4e-3
rk1420 n941__chipdriverout n942__chipdriverout 114.8e-3
rk1421 n942__chipdriverout n943__chipdriverout 360.5e-3
rk1422 n943__chipdriverout n944__chipdriverout 239.3e-3
rk1423 n944__chipdriverout n945__chipdriverout 118e-3
rk1425 n937__chipdriverout n938__chipdriverout 5.7692
rk1426 n937__chipdriverout n941__chipdriverout 3.75
rk1427 n937__chipdriverout n944__chipdriverout 3.75
rk1429 n948__chipdriverout n950__chipdriverout 207.4e-3
rk1430 n950__chipdriverout n951__chipdriverout 153.1e-3
rk1431 n951__chipdriverout n952__chipdriverout 338.1e-3
rk1432 n952__chipdriverout n953__chipdriverout 223.4e-3
rk1433 n953__chipdriverout n954__chipdriverout 137.1e-3
rk1434 n954__chipdriverout n955__chipdriverout 357.3e-3
rk1435 n955__chipdriverout n956__chipdriverout 220.2e-3
rk1436 n956__chipdriverout n957__chipdriverout 140.3e-3
rk1437 n957__chipdriverout n958__chipdriverout 338.1e-3
rk1438 n958__chipdriverout n959__chipdriverout 236.1e-3
rk1439 n959__chipdriverout n960__chipdriverout 124.4e-3
rk1441 n949__chipdriverout n950__chipdriverout 3.1
rk1442 n949__chipdriverout n953__chipdriverout 3.1
rk1443 n949__chipdriverout n956__chipdriverout 3.1
rk1444 n949__chipdriverout n959__chipdriverout 3.1
rk1445 n330__i0__i14__net1 n441__i0__i14__net1 125e-3
rk1446 n332__i0__i14__net1 n442__i0__i14__net1 125e-3
rk1448 n506__vddio n508__vddio 29.7e-3
rk1449 n508__vddio n509__vddio 330.8e-3
rk1450 n509__vddio n510__vddio 338.1e-3
rk1451 n510__vddio n511__vddio 42.07e-3
rk1452 n511__vddio n512__vddio 316.6e-3
rk1453 n512__vddio n513__vddio 357.3e-3
rk1454 n513__vddio n514__vddio 39.59e-3
rk1455 n514__vddio n515__vddio 319.1e-3
rk1456 n515__vddio n516__vddio 338.1e-3
rk1457 n516__vddio n517__vddio 51.97e-3
rk1458 n517__vddio n518__vddio 389.7e-3
rk1459 n507__vddio n508__vddio 3.1
rk1460 n507__vddio n511__vddio 3.1
rk1461 n507__vddio n514__vddio 3.1
rk1462 n507__vddio n517__vddio 3.1
rk1463 n322__vss n320__vss 54.44e-3
rk1464 n320__vss n317__vss 360.5e-3
rk1465 n317__vss n323__vss 294.3e-3
rk1466 n323__vss n316__vss 42.07e-3
rk1467 n316__vss n313__vss 360.5e-3
rk1468 n313__vss n324__vss 185e-3
rk1469 n324__vss n325__vss 262e-3
rk1470 n321__vss n322__vss 3.75
rk1471 n321__vss n323__vss 3.75
rk1472 n321__vss n324__vss 5.7692
rk1473 n341__i0__i14__net1 n453__i0__i14__net1 125e-3
rk1474 n343__i0__i14__net1 n454__i0__i14__net1 125e-3
rk1476 n977__chipdriverout n978__chipdriverout 12.37e-3
rk1477 n978__chipdriverout n979__chipdriverout 360.5e-3
rk1478 n979__chipdriverout n980__chipdriverout 223.4e-3
rk1479 n980__chipdriverout n981__chipdriverout 114.8e-3
rk1480 n981__chipdriverout n982__chipdriverout 360.5e-3
rk1481 n982__chipdriverout n983__chipdriverout 239.3e-3
rk1482 n983__chipdriverout n984__chipdriverout 118e-3
rk1484 n976__chipdriverout n977__chipdriverout 5.7692
rk1485 n976__chipdriverout n980__chipdriverout 3.75
rk1486 n976__chipdriverout n983__chipdriverout 3.75
rk1488 n987__chipdriverout n989__chipdriverout 207.4e-3
rk1489 n989__chipdriverout n990__chipdriverout 153.1e-3
rk1490 n990__chipdriverout n991__chipdriverout 338.1e-3
rk1491 n991__chipdriverout n992__chipdriverout 223.4e-3
rk1492 n992__chipdriverout n993__chipdriverout 137.1e-3
rk1493 n993__chipdriverout n994__chipdriverout 357.3e-3
rk1494 n994__chipdriverout n995__chipdriverout 220.2e-3
rk1495 n995__chipdriverout n996__chipdriverout 140.3e-3
rk1496 n996__chipdriverout n997__chipdriverout 338.1e-3
rk1497 n997__chipdriverout n998__chipdriverout 236.1e-3
rk1498 n998__chipdriverout n999__chipdriverout 124.4e-3
rk1500 n988__chipdriverout n989__chipdriverout 3.1
rk1501 n988__chipdriverout n992__chipdriverout 3.1
rk1502 n988__chipdriverout n995__chipdriverout 3.1
rk1503 n988__chipdriverout n998__chipdriverout 3.1
rk1507 n526__vddio n542__vddio 29.7e-3
rk1508 n542__vddio n529__vddio 330.8e-3
rk1509 n529__vddio n530__vddio 338.1e-3
rk1510 n530__vddio n543__vddio 42.07e-3
rk1511 n543__vddio n533__vddio 316.6e-3
rk1512 n533__vddio n534__vddio 357.3e-3
rk1513 n534__vddio n544__vddio 39.59e-3
rk1514 n544__vddio n537__vddio 319.1e-3
rk1515 n537__vddio n538__vddio 338.1e-3
rk1516 n538__vddio n545__vddio 51.97e-3
rk1517 n545__vddio n546__vddio 389.7e-3
rk1518 n541__vddio n542__vddio 3.1
rk1519 n541__vddio n543__vddio 3.1
rk1520 n541__vddio n544__vddio 3.1
rk1521 n541__vddio n545__vddio 3.1
rk1522 n335__vss n333__vss 54.44e-3
rk1523 n333__vss n330__vss 364.1e-3
rk1524 n330__vss n336__vss 299.7e-3
rk1525 n336__vss n329__vss 42.07e-3
rk1526 n329__vss n326__vss 364.1e-3
rk1527 n326__vss n337__vss 186.8e-3
rk1528 n337__vss n338__vss 262e-3
rk1529 n334__vss n335__vss 3.75
rk1530 n334__vss n336__vss 3.75
rk1531 n334__vss n337__vss 5.7692
rk1532 n357__i0__i14__net1 n469__i0__i14__net1 125e-3
rk1533 n359__i0__i14__net1 n470__i0__i14__net1 125e-3
rk1535 n1016__chipdriverout n1017__chipdriverout 12.37e-3
rk1536 n1017__chipdriverout n1018__chipdriverout 360.5e-3
rk1537 n1018__chipdriverout n1019__chipdriverout 223.4e-3
rk1538 n1019__chipdriverout n1020__chipdriverout 114.8e-3
rk1539 n1020__chipdriverout n1021__chipdriverout 360.5e-3
rk1540 n1021__chipdriverout n1022__chipdriverout 239.3e-3
rk1541 n1022__chipdriverout n1023__chipdriverout 118e-3
rk1543 n1015__chipdriverout n1016__chipdriverout 5.7692
rk1544 n1015__chipdriverout n1019__chipdriverout 3.75
rk1545 n1015__chipdriverout n1022__chipdriverout 3.75
rk1547 n1026__chipdriverout n1028__chipdriverout 209.2e-3
rk1548 n1028__chipdriverout n1029__chipdriverout 154.9e-3
rk1549 n1029__chipdriverout n1030__chipdriverout 341.7e-3
rk1550 n1030__chipdriverout n1031__chipdriverout 225.2e-3
rk1551 n1031__chipdriverout n1032__chipdriverout 138.9e-3
rk1552 n1032__chipdriverout n1033__chipdriverout 360.9e-3
rk1553 n1033__chipdriverout n1034__chipdriverout 222e-3
rk1554 n1034__chipdriverout n1035__chipdriverout 142.1e-3
rk1555 n1035__chipdriverout n1036__chipdriverout 341.7e-3
rk1556 n1036__chipdriverout n1037__chipdriverout 237.9e-3
rk1557 n1037__chipdriverout n1038__chipdriverout 126.2e-3
rk1559 n1027__chipdriverout n1028__chipdriverout 3.1
rk1560 n1027__chipdriverout n1031__chipdriverout 3.1
rk1561 n1027__chipdriverout n1034__chipdriverout 3.1
rk1562 n1027__chipdriverout n1037__chipdriverout 3.1
rk1563 n362__i0__i14__net1 n473__i0__i14__net1 125e-3
rk1564 n364__i0__i14__net1 n474__i0__i14__net1 125e-3
rk1565 n340__vss n341__vss 54.44e-3
rk1566 n341__vss n342__vss 360.5e-3
rk1567 n342__vss n343__vss 294.3e-3
rk1568 n343__vss n344__vss 42.07e-3
rk1569 n344__vss n345__vss 360.5e-3
rk1570 n345__vss n346__vss 185e-3
rk1571 n346__vss n347__vss 262e-3
rk1572 n339__vss n340__vss 3.75
rk1573 n339__vss n343__vss 3.75
rk1574 n339__vss n346__vss 5.7692
rk1576 n548__vddio n550__vddio 29.7e-3
rk1577 n550__vddio n551__vddio 330.8e-3
rk1578 n551__vddio n552__vddio 338.1e-3
rk1579 n552__vddio n553__vddio 42.07e-3
rk1580 n553__vddio n554__vddio 316.6e-3
rk1581 n554__vddio n555__vddio 357.3e-3
rk1582 n555__vddio n556__vddio 39.59e-3
rk1583 n556__vddio n557__vddio 319.1e-3
rk1584 n557__vddio n558__vddio 338.1e-3
rk1585 n558__vddio n559__vddio 51.97e-3
rk1586 n559__vddio n560__vddio 389.7e-3
rk1587 n549__vddio n550__vddio 3.1
rk1588 n549__vddio n553__vddio 3.1
rk1589 n549__vddio n556__vddio 3.1
rk1590 n549__vddio n559__vddio 3.1
rk1594 n1055__chipdriverout n1056__chipdriverout 12.37e-3
rk1595 n1056__chipdriverout n1057__chipdriverout 360.5e-3
rk1596 n1057__chipdriverout n1058__chipdriverout 223.4e-3
rk1597 n1058__chipdriverout n1059__chipdriverout 114.8e-3
rk1598 n1059__chipdriverout n1060__chipdriverout 360.5e-3
rk1599 n1060__chipdriverout n1061__chipdriverout 239.3e-3
rk1600 n1061__chipdriverout n1062__chipdriverout 118e-3
rk1602 n1054__chipdriverout n1055__chipdriverout 5.7692
rk1603 n1054__chipdriverout n1058__chipdriverout 3.75
rk1604 n1054__chipdriverout n1061__chipdriverout 3.75
rk1606 n1065__chipdriverout n1067__chipdriverout 209.2e-3
rk1607 n1067__chipdriverout n1068__chipdriverout 154.9e-3
rk1608 n1068__chipdriverout n1069__chipdriverout 341.7e-3
rk1609 n1069__chipdriverout n1070__chipdriverout 225.2e-3
rk1610 n1070__chipdriverout n1071__chipdriverout 138.9e-3
rk1611 n1071__chipdriverout n1072__chipdriverout 360.9e-3
rk1612 n1072__chipdriverout n1073__chipdriverout 222e-3
rk1613 n1073__chipdriverout n1074__chipdriverout 142.1e-3
rk1614 n1074__chipdriverout n1075__chipdriverout 341.7e-3
rk1615 n1075__chipdriverout n1076__chipdriverout 237.9e-3
rk1616 n1076__chipdriverout n1077__chipdriverout 126.2e-3
rk1618 n1066__chipdriverout n1067__chipdriverout 3.1
rk1619 n1066__chipdriverout n1070__chipdriverout 3.1
rk1620 n1066__chipdriverout n1073__chipdriverout 3.1
rk1621 n1066__chipdriverout n1076__chipdriverout 3.1
rk1624 n361__vss n359__vss 54.44e-3
rk1625 n359__vss n356__vss 360.5e-3
rk1626 n356__vss n362__vss 294.3e-3
rk1627 n362__vss n355__vss 42.07e-3
rk1628 n355__vss n352__vss 360.5e-3
rk1629 n352__vss n363__vss 185e-3
rk1630 n363__vss n364__vss 262e-3
rk1631 n360__vss n361__vss 3.75
rk1632 n360__vss n362__vss 3.75
rk1633 n360__vss n363__vss 5.7692
rk1635 n568__vddio n584__vddio 29.7e-3
rk1636 n584__vddio n571__vddio 330.8e-3
rk1637 n571__vddio n572__vddio 338.1e-3
rk1638 n572__vddio n585__vddio 42.07e-3
rk1639 n585__vddio n575__vddio 316.6e-3
rk1640 n575__vddio n576__vddio 357.3e-3
rk1641 n576__vddio n586__vddio 39.59e-3
rk1642 n586__vddio n579__vddio 319.1e-3
rk1643 n579__vddio n580__vddio 338.1e-3
rk1644 n580__vddio n587__vddio 51.97e-3
rk1645 n587__vddio n588__vddio 389.7e-3
rk1646 n583__vddio n584__vddio 3.1
rk1647 n583__vddio n585__vddio 3.1
rk1648 n583__vddio n586__vddio 3.1
rk1649 n583__vddio n587__vddio 3.1
rk1650 n389__i0__i14__net1 n501__i0__i14__net1 125e-3
rk1651 n391__i0__i14__net1 n502__i0__i14__net1 125e-3
rk1653 n1120__chipdriverout n1092__chipdriverout 12.37e-3
rk1654 n1092__chipdriverout n1095__chipdriverout 360.5e-3
rk1655 n1095__chipdriverout n1121__chipdriverout 223.4e-3
rk1656 n1121__chipdriverout n1096__chipdriverout 114.8e-3
rk1657 n1096__chipdriverout n1099__chipdriverout 360.5e-3
rk1658 n1099__chipdriverout n1122__chipdriverout 239.3e-3
rk1659 n1122__chipdriverout n1100__chipdriverout 118e-3
rk1661 n1119__chipdriverout n1120__chipdriverout 5.7692
rk1662 n1119__chipdriverout n1121__chipdriverout 3.75
rk1663 n1119__chipdriverout n1122__chipdriverout 3.75
rk1665 n1103__chipdriverout n1126__chipdriverout 207.4e-3
rk1666 n1126__chipdriverout n1104__chipdriverout 153.1e-3
rk1667 n1104__chipdriverout n1107__chipdriverout 338.1e-3
rk1668 n1107__chipdriverout n1127__chipdriverout 223.4e-3
rk1669 n1127__chipdriverout n1108__chipdriverout 137.1e-3
rk1670 n1108__chipdriverout n1111__chipdriverout 357.3e-3
rk1671 n1111__chipdriverout n1128__chipdriverout 220.2e-3
rk1672 n1128__chipdriverout n1112__chipdriverout 140.3e-3
rk1673 n1112__chipdriverout n1115__chipdriverout 338.1e-3
rk1674 n1115__chipdriverout n1129__chipdriverout 236.1e-3
rk1675 n1129__chipdriverout n1116__chipdriverout 124.4e-3
rk1677 n1125__chipdriverout n1126__chipdriverout 3.1
rk1678 n1125__chipdriverout n1127__chipdriverout 3.1
rk1679 n1125__chipdriverout n1128__chipdriverout 3.1
rk1680 n1125__chipdriverout n1129__chipdriverout 3.1
rk1681 n394__i0__i14__net1 n509__i0__i14__net1 125e-3
rk1682 n396__i0__i14__net1 n510__i0__i14__net1 125e-3
rk1684 n590__vddio n592__vddio 29.7e-3
rk1685 n592__vddio n593__vddio 330.8e-3
rk1686 n593__vddio n594__vddio 338.1e-3
rk1687 n594__vddio n595__vddio 42.07e-3
rk1688 n595__vddio n596__vddio 316.6e-3
rk1689 n596__vddio n597__vddio 357.3e-3
rk1690 n597__vddio n598__vddio 39.59e-3
rk1691 n598__vddio n599__vddio 319.1e-3
rk1692 n599__vddio n600__vddio 338.1e-3
rk1693 n600__vddio n601__vddio 51.97e-3
rk1694 n601__vddio n602__vddio 389.7e-3
rk1695 n591__vddio n592__vddio 3.1
rk1696 n591__vddio n595__vddio 3.1
rk1697 n591__vddio n598__vddio 3.1
rk1698 n591__vddio n601__vddio 3.1
rk1699 n366__vss n367__vss 54.44e-3
rk1700 n367__vss n368__vss 360.5e-3
rk1701 n368__vss n369__vss 294.3e-3
rk1702 n369__vss n370__vss 42.07e-3
rk1703 n370__vss n371__vss 360.5e-3
rk1704 n371__vss n372__vss 185e-3
rk1705 n372__vss n373__vss 262e-3
rk1706 n365__vss n366__vss 3.75
rk1707 n365__vss n369__vss 3.75
rk1708 n365__vss n372__vss 5.7692
rk1709 n405__i0__i14__net1 n517__i0__i14__net1 125e-3
rk1710 n407__i0__i14__net1 n518__i0__i14__net1 125e-3
rk1712 n1159__chipdriverout n1131__chipdriverout 12.37e-3
rk1713 n1131__chipdriverout n1134__chipdriverout 360.5e-3
rk1714 n1134__chipdriverout n1160__chipdriverout 223.4e-3
rk1715 n1160__chipdriverout n1135__chipdriverout 114.8e-3
rk1716 n1135__chipdriverout n1138__chipdriverout 360.5e-3
rk1717 n1138__chipdriverout n1161__chipdriverout 239.3e-3
rk1718 n1161__chipdriverout n1139__chipdriverout 118e-3
rk1720 n1158__chipdriverout n1159__chipdriverout 5.7692
rk1721 n1158__chipdriverout n1160__chipdriverout 3.75
rk1722 n1158__chipdriverout n1161__chipdriverout 3.75
rk1724 n1142__chipdriverout n1165__chipdriverout 207.4e-3
rk1725 n1165__chipdriverout n1143__chipdriverout 153.1e-3
rk1726 n1143__chipdriverout n1146__chipdriverout 338.1e-3
rk1727 n1146__chipdriverout n1166__chipdriverout 223.4e-3
rk1728 n1166__chipdriverout n1147__chipdriverout 137.1e-3
rk1729 n1147__chipdriverout n1150__chipdriverout 357.3e-3
rk1730 n1150__chipdriverout n1167__chipdriverout 220.2e-3
rk1731 n1167__chipdriverout n1151__chipdriverout 140.3e-3
rk1732 n1151__chipdriverout n1154__chipdriverout 338.1e-3
rk1733 n1154__chipdriverout n1168__chipdriverout 236.1e-3
rk1734 n1168__chipdriverout n1155__chipdriverout 124.4e-3
rk1736 n1164__chipdriverout n1165__chipdriverout 3.1
rk1737 n1164__chipdriverout n1166__chipdriverout 3.1
rk1738 n1164__chipdriverout n1167__chipdriverout 3.1
rk1739 n1164__chipdriverout n1168__chipdriverout 3.1
rk1740 n410__i0__i14__net1 n525__i0__i14__net1 125e-3
rk1741 n412__i0__i14__net1 n526__i0__i14__net1 125e-3
rk1743 n610__vddio n626__vddio 29.7e-3
rk1744 n626__vddio n613__vddio 330.8e-3
rk1745 n613__vddio n614__vddio 338.1e-3
rk1746 n614__vddio n627__vddio 42.07e-3
rk1747 n627__vddio n617__vddio 316.6e-3
rk1748 n617__vddio n618__vddio 357.3e-3
rk1749 n618__vddio n628__vddio 39.59e-3
rk1750 n628__vddio n621__vddio 319.1e-3
rk1751 n621__vddio n622__vddio 338.1e-3
rk1752 n622__vddio n629__vddio 51.97e-3
rk1753 n629__vddio n630__vddio 389.7e-3
rk1754 n625__vddio n626__vddio 3.1
rk1755 n625__vddio n627__vddio 3.1
rk1756 n625__vddio n628__vddio 3.1
rk1757 n625__vddio n629__vddio 3.1
rk1758 n387__vss n385__vss 54.44e-3
rk1759 n385__vss n382__vss 360.5e-3
rk1760 n382__vss n388__vss 294.3e-3
rk1761 n388__vss n381__vss 42.07e-3
rk1762 n381__vss n378__vss 360.5e-3
rk1763 n378__vss n389__vss 185e-3
rk1764 n389__vss n390__vss 262e-3
rk1765 n386__vss n387__vss 3.75
rk1766 n386__vss n388__vss 3.75
rk1767 n386__vss n389__vss 5.7692
rk1768 n421__i0__i14__net1 n533__i0__i14__net1 125e-3
rk1769 n423__i0__i14__net1 n534__i0__i14__net1 125e-3
rk1771 n1172__chipdriverout n1173__chipdriverout 12.37e-3
rk1772 n1173__chipdriverout n1174__chipdriverout 360.5e-3
rk1773 n1174__chipdriverout n1175__chipdriverout 223.4e-3
rk1774 n1175__chipdriverout n1176__chipdriverout 114.8e-3
rk1775 n1176__chipdriverout n1177__chipdriverout 360.5e-3
rk1776 n1177__chipdriverout n1178__chipdriverout 239.3e-3
rk1777 n1178__chipdriverout n1179__chipdriverout 118e-3
rk1779 n1171__chipdriverout n1172__chipdriverout 5.7692
rk1780 n1171__chipdriverout n1175__chipdriverout 3.75
rk1781 n1171__chipdriverout n1178__chipdriverout 3.75
rk1783 n1182__chipdriverout n1184__chipdriverout 208.2e-3
rk1784 n1184__chipdriverout n1185__chipdriverout 153.9e-3
rk1785 n1185__chipdriverout n1186__chipdriverout 339.8e-3
rk1786 n1186__chipdriverout n1187__chipdriverout 224.2e-3
rk1787 n1187__chipdriverout n1188__chipdriverout 138e-3
rk1788 n1188__chipdriverout n1189__chipdriverout 358.9e-3
rk1789 n1189__chipdriverout n1190__chipdriverout 221e-3
rk1790 n1190__chipdriverout n1191__chipdriverout 141.2e-3
rk1791 n1191__chipdriverout n1192__chipdriverout 339.8e-3
rk1792 n1192__chipdriverout n1193__chipdriverout 236.9e-3
rk1793 n1193__chipdriverout n1194__chipdriverout 125.2e-3
rk1795 n1183__chipdriverout n1184__chipdriverout 3.1
rk1796 n1183__chipdriverout n1187__chipdriverout 3.1
rk1797 n1183__chipdriverout n1190__chipdriverout 3.1
rk1798 n1183__chipdriverout n1193__chipdriverout 3.1
rk1801 n392__vss n393__vss 54.44e-3
rk1802 n393__vss n394__vss 360.5e-3
rk1803 n394__vss n395__vss 294.3e-3
rk1804 n395__vss n396__vss 42.07e-3
rk1805 n396__vss n397__vss 360.5e-3
rk1806 n397__vss n398__vss 185e-3
rk1807 n398__vss n399__vss 262e-3
rk1808 n391__vss n392__vss 3.75
rk1809 n391__vss n395__vss 3.75
rk1810 n391__vss n398__vss 5.7692
rk1812 n632__vddio n634__vddio 29.7e-3
rk1813 n634__vddio n635__vddio 330.8e-3
rk1814 n635__vddio n636__vddio 338.1e-3
rk1815 n636__vddio n637__vddio 42.07e-3
rk1816 n637__vddio n638__vddio 316.6e-3
rk1817 n638__vddio n639__vddio 357.3e-3
rk1818 n639__vddio n640__vddio 39.59e-3
rk1819 n640__vddio n641__vddio 319.1e-3
rk1820 n641__vddio n642__vddio 338.1e-3
rk1821 n642__vddio n643__vddio 51.97e-3
rk1822 n643__vddio n644__vddio 389.7e-3
rk1823 n633__vddio n634__vddio 3.1
rk1824 n633__vddio n637__vddio 3.1
rk1825 n633__vddio n640__vddio 3.1
rk1826 n633__vddio n643__vddio 3.1
rk1827 n434__i0__i14__net1 n549__i0__i14__net1 125e-3
rk1828 n436__i0__i14__net1 n550__i0__i14__net1 125e-3
rk1830 n1211__chipdriverout n1212__chipdriverout 12.37e-3
rk1831 n1212__chipdriverout n1213__chipdriverout 360.5e-3
rk1832 n1213__chipdriverout n1214__chipdriverout 223.4e-3
rk1833 n1214__chipdriverout n1215__chipdriverout 114.8e-3
rk1834 n1215__chipdriverout n1216__chipdriverout 360.5e-3
rk1835 n1216__chipdriverout n1217__chipdriverout 239.3e-3
rk1836 n1217__chipdriverout n1218__chipdriverout 118e-3
rk1838 n1210__chipdriverout n1211__chipdriverout 5.7692
rk1839 n1210__chipdriverout n1214__chipdriverout 3.75
rk1840 n1210__chipdriverout n1217__chipdriverout 3.75
rk1842 n1221__chipdriverout n1223__chipdriverout 209.2e-3
rk1843 n1223__chipdriverout n1224__chipdriverout 154.9e-3
rk1844 n1224__chipdriverout n1225__chipdriverout 341.7e-3
rk1845 n1225__chipdriverout n1226__chipdriverout 225.2e-3
rk1846 n1226__chipdriverout n1227__chipdriverout 138.9e-3
rk1847 n1227__chipdriverout n1228__chipdriverout 360.9e-3
rk1848 n1228__chipdriverout n1229__chipdriverout 222e-3
rk1849 n1229__chipdriverout n1230__chipdriverout 142.1e-3
rk1850 n1230__chipdriverout n1231__chipdriverout 341.7e-3
rk1851 n1231__chipdriverout n1232__chipdriverout 237.9e-3
rk1852 n1232__chipdriverout n1233__chipdriverout 126.2e-3
rk1854 n1222__chipdriverout n1223__chipdriverout 3.1
rk1855 n1222__chipdriverout n1226__chipdriverout 3.1
rk1856 n1222__chipdriverout n1229__chipdriverout 3.1
rk1857 n1222__chipdriverout n1232__chipdriverout 3.1
rk1860 n413__vss n411__vss 54.44e-3
rk1861 n411__vss n408__vss 360.5e-3
rk1862 n408__vss n414__vss 294.3e-3
rk1863 n414__vss n407__vss 42.07e-3
rk1864 n407__vss n404__vss 360.5e-3
rk1865 n404__vss n415__vss 185e-3
rk1866 n415__vss n416__vss 262e-3
rk1867 n412__vss n413__vss 3.75
rk1868 n412__vss n414__vss 3.75
rk1869 n412__vss n415__vss 5.7692
rk1871 n652__vddio n668__vddio 29.7e-3
rk1872 n668__vddio n655__vddio 330.8e-3
rk1873 n655__vddio n656__vddio 338.1e-3
rk1874 n656__vddio n669__vddio 42.07e-3
rk1875 n669__vddio n659__vddio 316.6e-3
rk1876 n659__vddio n660__vddio 357.3e-3
rk1877 n660__vddio n670__vddio 39.59e-3
rk1878 n670__vddio n663__vddio 319.1e-3
rk1879 n663__vddio n664__vddio 338.1e-3
rk1880 n664__vddio n671__vddio 51.97e-3
rk1881 n671__vddio n672__vddio 389.7e-3
rk1882 n667__vddio n668__vddio 3.1
rk1883 n667__vddio n669__vddio 3.1
rk1884 n667__vddio n670__vddio 3.1
rk1885 n667__vddio n671__vddio 3.1
rk1889 n16__clk n2__clk 45.0049
rk1891 n18__clk n5__clk 45.0049
rk1893 n1250__chipdriverout n1251__chipdriverout 12.37e-3
rk1894 n1251__chipdriverout n1252__chipdriverout 360.5e-3
rk1895 n1252__chipdriverout n1253__chipdriverout 223.4e-3
rk1896 n1253__chipdriverout n1254__chipdriverout 114.8e-3
rk1897 n1254__chipdriverout n1255__chipdriverout 360.5e-3
rk1898 n1255__chipdriverout n1256__chipdriverout 239.3e-3
rk1899 n1256__chipdriverout n1257__chipdriverout 118e-3
rk1901 n1249__chipdriverout n1250__chipdriverout 5.7692
rk1902 n1249__chipdriverout n1253__chipdriverout 3.75
rk1903 n1249__chipdriverout n1256__chipdriverout 3.75
rk1905 n1260__chipdriverout n1262__chipdriverout 207.4e-3
rk1906 n1262__chipdriverout n1263__chipdriverout 153.1e-3
rk1907 n1263__chipdriverout n1264__chipdriverout 338.1e-3
rk1908 n1264__chipdriverout n1265__chipdriverout 223.4e-3
rk1909 n1265__chipdriverout n1266__chipdriverout 137.1e-3
rk1910 n1266__chipdriverout n1267__chipdriverout 357.3e-3
rk1911 n1267__chipdriverout n1268__chipdriverout 220.2e-3
rk1912 n1268__chipdriverout n1269__chipdriverout 140.3e-3
rk1913 n1269__chipdriverout n1270__chipdriverout 338.1e-3
rk1914 n1270__chipdriverout n1271__chipdriverout 236.1e-3
rk1915 n1271__chipdriverout n1272__chipdriverout 124.4e-3
rk1917 n1261__chipdriverout n1262__chipdriverout 3.1
rk1918 n1261__chipdriverout n1265__chipdriverout 3.1
rk1919 n1261__chipdriverout n1268__chipdriverout 3.1
rk1920 n1261__chipdriverout n1271__chipdriverout 3.1
rk1921 n5__i3__net10 n6__i3__net10 31.1958
rk1922 n6__i3__net10 n7__i3__net10 75.1571
rk1923 n5__i1__net1 n6__i1__net1 31.1958
rk1924 n6__i1__net1 n7__i1__net1 75.1571
rk1925 n462__i0__i14__net1 n569__i0__i14__net1 125e-3
rk1926 n464__i0__i14__net1 n570__i0__i14__net1 125e-3
rk1928 n674__vddio n676__vddio 29.7e-3
rk1929 n676__vddio n677__vddio 330.8e-3
rk1930 n677__vddio n678__vddio 338.1e-3
rk1931 n678__vddio n679__vddio 42.07e-3
rk1932 n679__vddio n680__vddio 316.6e-3
rk1933 n680__vddio n681__vddio 357.3e-3
rk1934 n681__vddio n682__vddio 39.59e-3
rk1935 n682__vddio n683__vddio 319.1e-3
rk1936 n683__vddio n684__vddio 338.1e-3
rk1937 n684__vddio n685__vddio 51.97e-3
rk1938 n685__vddio n686__vddio 389.7e-3
rk1939 n675__vddio n676__vddio 3.1
rk1940 n675__vddio n679__vddio 3.1
rk1941 n675__vddio n682__vddio 3.1
rk1942 n675__vddio n685__vddio 3.1
rk1943 n428__vss n425__vss 54.44e-3
rk1944 n425__vss n424__vss 360.5e-3
rk1945 n424__vss n429__vss 294.3e-3
rk1946 n429__vss n421__vss 42.07e-3
rk1947 n421__vss n420__vss 360.5e-3
rk1948 n420__vss n430__vss 185e-3
rk1949 n430__vss n431__vss 262e-3
rk1950 n427__vss n428__vss 3.75
rk1951 n427__vss n429__vss 3.75
rk1952 n427__vss n430__vss 5.7692
rk1953 n466__i0__i14__net1 n581__i0__i14__net1 125e-3
rk1954 n468__i0__i14__net1 n582__i0__i14__net1 125e-3
rk1956 n12__s n2__s 45.0049
rk1958 n3__i3__net9 n6__i3__net9 502.4e-3
rk1960 n1315__chipdriverout n1288__chipdriverout 12.37e-3
rk1961 n1288__chipdriverout n1289__chipdriverout 360.5e-3
rk1962 n1289__chipdriverout n1316__chipdriverout 223.4e-3
rk1963 n1316__chipdriverout n1292__chipdriverout 114.8e-3
rk1964 n1292__chipdriverout n1293__chipdriverout 360.5e-3
rk1965 n1293__chipdriverout n1317__chipdriverout 239.3e-3
rk1966 n1317__chipdriverout n1296__chipdriverout 118e-3
rk1968 n1314__chipdriverout n1315__chipdriverout 5.7692
rk1969 n1314__chipdriverout n1316__chipdriverout 3.75
rk1970 n1314__chipdriverout n1317__chipdriverout 3.75
rk1972 n1297__chipdriverout n1321__chipdriverout 207.4e-3
rk1973 n1321__chipdriverout n1300__chipdriverout 153.1e-3
rk1974 n1300__chipdriverout n1301__chipdriverout 338.1e-3
rk1975 n1301__chipdriverout n1322__chipdriverout 223.4e-3
rk1976 n1322__chipdriverout n1304__chipdriverout 137.1e-3
rk1977 n1304__chipdriverout n1305__chipdriverout 357.3e-3
rk1978 n1305__chipdriverout n1323__chipdriverout 220.2e-3
rk1979 n1323__chipdriverout n1308__chipdriverout 140.3e-3
rk1980 n1308__chipdriverout n1309__chipdriverout 338.1e-3
rk1981 n1309__chipdriverout n1324__chipdriverout 236.1e-3
rk1982 n1324__chipdriverout n1312__chipdriverout 124.4e-3
rk1984 n1320__chipdriverout n1321__chipdriverout 3.1
rk1985 n1320__chipdriverout n1322__chipdriverout 3.1
rk1986 n1320__chipdriverout n1323__chipdriverout 3.1
rk1987 n1320__chipdriverout n1324__chipdriverout 3.1
rk1988 n478__i0__i14__net1 n585__i0__i14__net1 125e-3
rk1989 n480__i0__i14__net1 n586__i0__i14__net1 125e-3
rk1991 n695__vddio n697__vddio 29.7e-3
rk1992 n697__vddio n698__vddio 330.8e-3
rk1993 n698__vddio n699__vddio 338.1e-3
rk1994 n699__vddio n700__vddio 42.07e-3
rk1995 n700__vddio n701__vddio 316.6e-3
rk1996 n701__vddio n702__vddio 357.3e-3
rk1997 n702__vddio n703__vddio 39.59e-3
rk1998 n703__vddio n704__vddio 319.1e-3
rk1999 n704__vddio n705__vddio 338.1e-3
rk2000 n705__vddio n706__vddio 51.97e-3
rk2001 n706__vddio n707__vddio 389.7e-3
rk2002 n696__vddio n697__vddio 3.1
rk2003 n696__vddio n700__vddio 3.1
rk2004 n696__vddio n703__vddio 3.1
rk2005 n696__vddio n706__vddio 3.1
rk2006 n441__vss n438__vss 54.44e-3
rk2007 n438__vss n437__vss 360.5e-3
rk2008 n437__vss n442__vss 294.3e-3
rk2009 n442__vss n434__vss 42.07e-3
rk2010 n434__vss n433__vss 360.5e-3
rk2011 n433__vss n443__vss 185e-3
rk2012 n443__vss n444__vss 262e-3
rk2013 n440__vss n441__vss 3.75
rk2014 n440__vss n442__vss 3.75
rk2015 n440__vss n443__vss 5.7692
rk2016 n3__vdd n1__vdd 31.2141
rk2017 n1__vdd n4__vdd 75.2406
rk2018 i3__i0__net4 n2__i3__i0__net4 62.1818
rk2019 i3__i0__net1 n2__i3__i0__net1 150.192
rk2020 n21__clk n8__clk 505.2e-3
rk2021 n9__i3__net10 n2__i3__net10 505.2e-3
rk2022 n482__i0__i14__net1 n597__i0__i14__net1 125e-3
rk2023 n484__i0__i14__net1 n598__i0__i14__net1 125e-3
rk2025 n1328__chipdriverout n1329__chipdriverout 12.37e-3
rk2026 n1329__chipdriverout n1330__chipdriverout 360.5e-3
rk2027 n1330__chipdriverout n1331__chipdriverout 223.4e-3
rk2028 n1331__chipdriverout n1332__chipdriverout 114.8e-3
rk2029 n1332__chipdriverout n1333__chipdriverout 360.5e-3
rk2030 n1333__chipdriverout n1334__chipdriverout 239.3e-3
rk2031 n1334__chipdriverout n1335__chipdriverout 118e-3
rk2033 n1327__chipdriverout n1328__chipdriverout 5.7692
rk2034 n1327__chipdriverout n1331__chipdriverout 3.75
rk2035 n1327__chipdriverout n1334__chipdriverout 3.75
rk2037 n1338__chipdriverout n1340__chipdriverout 208.2e-3
rk2038 n1340__chipdriverout n1341__chipdriverout 153.9e-3
rk2039 n1341__chipdriverout n1342__chipdriverout 339.8e-3
rk2040 n1342__chipdriverout n1343__chipdriverout 224.2e-3
rk2041 n1343__chipdriverout n1344__chipdriverout 138e-3
rk2042 n1344__chipdriverout n1345__chipdriverout 358.9e-3
rk2043 n1345__chipdriverout n1346__chipdriverout 221e-3
rk2044 n1346__chipdriverout n1347__chipdriverout 141.2e-3
rk2045 n1347__chipdriverout n1348__chipdriverout 339.8e-3
rk2046 n1348__chipdriverout n1349__chipdriverout 236.9e-3
rk2047 n1349__chipdriverout n1350__chipdriverout 125.2e-3
rk2049 n1339__chipdriverout n1340__chipdriverout 3.1
rk2050 n1339__chipdriverout n1343__chipdriverout 3.1
rk2051 n1339__chipdriverout n1346__chipdriverout 3.1
rk2052 n1339__chipdriverout n1349__chipdriverout 3.1
rk2053 n490__i0__i14__net1 n605__i0__i14__net1 125e-3
rk2054 n492__i0__i14__net1 n606__i0__i14__net1 125e-3
rk2055 n1__r2 n2__r2 31.2292
rk2056 n2__r2 n3__r2 75.2548
rk2058 n716__vddio n718__vddio 29.7e-3
rk2059 n718__vddio n719__vddio 330.8e-3
rk2060 n719__vddio n720__vddio 338.1e-3
rk2061 n720__vddio n721__vddio 42.07e-3
rk2062 n721__vddio n722__vddio 316.6e-3
rk2063 n722__vddio n723__vddio 357.3e-3
rk2064 n723__vddio n724__vddio 39.59e-3
rk2065 n724__vddio n725__vddio 319.1e-3
rk2066 n725__vddio n726__vddio 338.1e-3
rk2067 n726__vddio n727__vddio 51.97e-3
rk2068 n727__vddio n728__vddio 389.7e-3
rk2069 n717__vddio n718__vddio 3.1
rk2070 n717__vddio n721__vddio 3.1
rk2071 n717__vddio n724__vddio 3.1
rk2072 n717__vddio n727__vddio 3.1
rk2073 n446__vss n447__vss 54.44e-3
rk2074 n447__vss n448__vss 360.5e-3
rk2075 n448__vss n449__vss 294.3e-3
rk2076 n449__vss n450__vss 42.07e-3
rk2077 n450__vss n451__vss 360.5e-3
rk2078 n451__vss n452__vss 185e-3
rk2079 n452__vss n453__vss 262e-3
rk2080 n445__vss n446__vss 3.75
rk2081 n445__vss n449__vss 3.75
rk2082 n445__vss n452__vss 5.7692
rk2083 n5__i3__i0__net2 n6__i3__i0__net2 31.2572
rk2084 n6__i3__i0__net2 n7__i3__i0__net2 75.2527
rk2085 n6__i3__i0__net2 n3__i3__i0__net2 225.7e-3
rk2086 n4__i1__i9__net4 n6__i1__i9__net4 1.1698
rk2087 n6__i1__i9__net4 n8__i1__i9__net4 433.2e-3
rk2088 n8__i1__i9__net4 n2__i1__i9__net4 477.9e-3
rk2089 n5__i1__i9__net4 n6__i1__i9__net4 75
rk2090 n7__i1__i9__net4 n8__i1__i9__net4 31
rk2091 n7__s n15__s 1.2751
rk2092 n15__s n5__s 5.036e-3
rk2093 n498__i0__i14__net1 n613__i0__i14__net1 125e-3
rk2094 n500__i0__i14__net1 n614__i0__i14__net1 125e-3
rk2095 n5__i1__net3 n6__i1__net3 75.2339
rk2096 n6__i1__net3 n8__i1__net3 211.2e-3
rk2097 n8__i1__net3 n10__i1__net3 1.0822
rk2098 n10__i1__net3 n11__i1__net3 75.5164
rk2099 n7__i1__net3 n8__i1__net3 31
rk2100 n9__i1__net3 n10__i1__net3 31
rk2102 n1367__chipdriverout n1368__chipdriverout 12.37e-3
rk2103 n1368__chipdriverout n1369__chipdriverout 360.5e-3
rk2104 n1369__chipdriverout n1370__chipdriverout 223.4e-3
rk2105 n1370__chipdriverout n1371__chipdriverout 114.8e-3
rk2106 n1371__chipdriverout n1372__chipdriverout 360.5e-3
rk2107 n1372__chipdriverout n1373__chipdriverout 239.3e-3
rk2108 n1373__chipdriverout n1374__chipdriverout 118e-3
rk2110 n1366__chipdriverout n1367__chipdriverout 5.7692
rk2111 n1366__chipdriverout n1370__chipdriverout 3.75
rk2112 n1366__chipdriverout n1373__chipdriverout 3.75
rk2114 n1377__chipdriverout n1379__chipdriverout 207.4e-3
rk2115 n1379__chipdriverout n1380__chipdriverout 153.1e-3
rk2116 n1380__chipdriverout n1381__chipdriverout 338.1e-3
rk2117 n1381__chipdriverout n1382__chipdriverout 223.4e-3
rk2118 n1382__chipdriverout n1383__chipdriverout 137.1e-3
rk2119 n1383__chipdriverout n1384__chipdriverout 357.3e-3
rk2120 n1384__chipdriverout n1385__chipdriverout 220.2e-3
rk2121 n1385__chipdriverout n1386__chipdriverout 140.3e-3
rk2122 n1386__chipdriverout n1387__chipdriverout 338.1e-3
rk2123 n1387__chipdriverout n1388__chipdriverout 236.1e-3
rk2124 n1388__chipdriverout n1389__chipdriverout 124.4e-3
rk2126 n1378__chipdriverout n1379__chipdriverout 3.1
rk2127 n1378__chipdriverout n1382__chipdriverout 3.1
rk2128 n1378__chipdriverout n1385__chipdriverout 3.1
rk2129 n1378__chipdriverout n1388__chipdriverout 3.1
rk2132 i3__i0__net3 n2__i3__i0__net3 62.1818
rk2133 i3__i0__net5 n2__i3__i0__net5 150.192
rk2134 n10__clk n22__clk 4.864e-3
rk2135 n11__i3__net10 n4__i3__net10 507.6e-3
rk2137 n14__i1__net3 n3__i1__net3 4.864e-3
rk2139 n737__vddio n739__vddio 29.7e-3
rk2140 n739__vddio n740__vddio 330.8e-3
rk2141 n740__vddio n741__vddio 338.1e-3
rk2142 n741__vddio n742__vddio 42.07e-3
rk2143 n742__vddio n743__vddio 316.6e-3
rk2144 n743__vddio n744__vddio 357.3e-3
rk2145 n744__vddio n745__vddio 39.59e-3
rk2146 n745__vddio n746__vddio 319.1e-3
rk2147 n746__vddio n747__vddio 338.1e-3
rk2148 n747__vddio n748__vddio 51.97e-3
rk2149 n748__vddio n749__vddio 389.7e-3
rk2150 n738__vddio n739__vddio 3.1
rk2151 n738__vddio n742__vddio 3.1
rk2152 n738__vddio n745__vddio 3.1
rk2153 n738__vddio n748__vddio 3.1
rk2154 n459__vss n460__vss 54.44e-3
rk2155 n460__vss n461__vss 360.5e-3
rk2156 n461__vss n462__vss 294.3e-3
rk2157 n462__vss n463__vss 42.07e-3
rk2158 n463__vss n464__vss 360.5e-3
rk2159 n464__vss n465__vss 185e-3
rk2160 n465__vss n466__vss 262e-3
rk2161 n458__vss n459__vss 3.75
rk2162 n458__vss n462__vss 3.75
rk2163 n458__vss n465__vss 5.7692
rk2164 n514__i0__i14__net1 n629__i0__i14__net1 125e-3
rk2165 n516__i0__i14__net1 n630__i0__i14__net1 125e-3
rk2167 n1406__chipdriverout n1407__chipdriverout 12.37e-3
rk2168 n1407__chipdriverout n1408__chipdriverout 360.5e-3
rk2169 n1408__chipdriverout n1409__chipdriverout 223.4e-3
rk2170 n1409__chipdriverout n1410__chipdriverout 114.8e-3
rk2171 n1410__chipdriverout n1411__chipdriverout 360.5e-3
rk2172 n1411__chipdriverout n1412__chipdriverout 239.3e-3
rk2173 n1412__chipdriverout n1413__chipdriverout 118e-3
rk2175 n1405__chipdriverout n1406__chipdriverout 5.7692
rk2176 n1405__chipdriverout n1409__chipdriverout 3.75
rk2177 n1405__chipdriverout n1412__chipdriverout 3.75
rk2179 n1416__chipdriverout n1418__chipdriverout 207.4e-3
rk2180 n1418__chipdriverout n1419__chipdriverout 153.1e-3
rk2181 n1419__chipdriverout n1420__chipdriverout 338.1e-3
rk2182 n1420__chipdriverout n1421__chipdriverout 223.4e-3
rk2183 n1421__chipdriverout n1422__chipdriverout 137.1e-3
rk2184 n1422__chipdriverout n1423__chipdriverout 357.3e-3
rk2185 n1423__chipdriverout n1424__chipdriverout 220.2e-3
rk2186 n1424__chipdriverout n1425__chipdriverout 140.3e-3
rk2187 n1425__chipdriverout n1426__chipdriverout 338.1e-3
rk2188 n1426__chipdriverout n1427__chipdriverout 236.1e-3
rk2189 n1427__chipdriverout n1428__chipdriverout 124.4e-3
rk2191 n1417__chipdriverout n1418__chipdriverout 3.1
rk2192 n1417__chipdriverout n1421__chipdriverout 3.1
rk2193 n1417__chipdriverout n1424__chipdriverout 3.1
rk2194 n1417__chipdriverout n1427__chipdriverout 3.1
rk2195 n522__i0__i14__net1 n637__i0__i14__net1 125e-3
rk2196 n524__i0__i14__net1 n638__i0__i14__net1 125e-3
rk2197 n15__i3__net13 n16__i3__net13 2.588e-3
rk2198 n16__i3__net13 n17__i3__net13 375.6e-3
rk2199 n17__i3__net13 n18__i3__net13 31.1276
rk2200 n17__i3__net13 n19__i3__net13 260.5e-3
rk2201 n19__i3__net13 n20__i3__net13 500e-3
rk2202 n14__i3__net13 n15__i3__net13 75
rk2203 n2__i3__net13 n19__i3__net13 45
rk2204 i1__i1__net21 n2__i1__i1__net21 62.1818
rk2205 i1__i1__net23 n2__i1__i1__net23 150.192
rk2206 n26__clk n12__clk 505.2e-3
rk2207 n11__i1__net1 n2__i1__net1 505.2e-3
rk2208 n9__i3__net9 n10__i3__net9 31.3335
rk2209 n10__i3__net9 n11__i3__net9 75.0212
rk2211 n758__vddio n760__vddio 29.7e-3
rk2212 n760__vddio n761__vddio 330.8e-3
rk2213 n761__vddio n762__vddio 338.1e-3
rk2214 n762__vddio n763__vddio 42.07e-3
rk2215 n763__vddio n764__vddio 316.6e-3
rk2216 n764__vddio n765__vddio 357.3e-3
rk2217 n765__vddio n766__vddio 39.59e-3
rk2218 n766__vddio n767__vddio 319.1e-3
rk2219 n767__vddio n768__vddio 338.1e-3
rk2220 n768__vddio n769__vddio 51.97e-3
rk2221 n769__vddio n770__vddio 389.7e-3
rk2222 n759__vddio n760__vddio 3.1
rk2223 n759__vddio n763__vddio 3.1
rk2224 n759__vddio n766__vddio 3.1
rk2225 n759__vddio n769__vddio 3.1
rk2226 n472__vss n473__vss 54.44e-3
rk2227 n473__vss n474__vss 360.5e-3
rk2228 n474__vss n475__vss 294.3e-3
rk2229 n475__vss n476__vss 42.07e-3
rk2230 n476__vss n477__vss 360.5e-3
rk2231 n477__vss n478__vss 185e-3
rk2232 n478__vss n479__vss 262e-3
rk2233 n471__vss n472__vss 3.75
rk2234 n471__vss n475__vss 3.75
rk2235 n471__vss n478__vss 5.7692
rk2236 n530__i0__i14__net1 n641__i0__i14__net1 125e-3
rk2237 n532__i0__i14__net1 n642__i0__i14__net1 125e-3
rk2239 n1445__chipdriverout n1446__chipdriverout 12.37e-3
rk2240 n1446__chipdriverout n1447__chipdriverout 360.5e-3
rk2241 n1447__chipdriverout n1448__chipdriverout 223.4e-3
rk2242 n1448__chipdriverout n1449__chipdriverout 114.8e-3
rk2243 n1449__chipdriverout n1450__chipdriverout 360.5e-3
rk2244 n1450__chipdriverout n1451__chipdriverout 239.3e-3
rk2245 n1451__chipdriverout n1452__chipdriverout 118e-3
rk2247 n1444__chipdriverout n1445__chipdriverout 5.7692
rk2248 n1444__chipdriverout n1448__chipdriverout 3.75
rk2249 n1444__chipdriverout n1451__chipdriverout 3.75
rk2251 n1455__chipdriverout n1457__chipdriverout 207.4e-3
rk2252 n1457__chipdriverout n1458__chipdriverout 153.1e-3
rk2253 n1458__chipdriverout n1459__chipdriverout 338.1e-3
rk2254 n1459__chipdriverout n1460__chipdriverout 223.4e-3
rk2255 n1460__chipdriverout n1461__chipdriverout 137.1e-3
rk2256 n1461__chipdriverout n1462__chipdriverout 357.3e-3
rk2257 n1462__chipdriverout n1463__chipdriverout 220.2e-3
rk2258 n1463__chipdriverout n1464__chipdriverout 140.3e-3
rk2259 n1464__chipdriverout n1465__chipdriverout 338.1e-3
rk2260 n1465__chipdriverout n1466__chipdriverout 236.1e-3
rk2261 n1466__chipdriverout n1467__chipdriverout 124.4e-3
rk2263 n1456__chipdriverout n1457__chipdriverout 3.1
rk2264 n1456__chipdriverout n1460__chipdriverout 3.1
rk2265 n1456__chipdriverout n1463__chipdriverout 3.1
rk2266 n1456__chipdriverout n1466__chipdriverout 3.1
rk2268 n22__i3__net13 n5__i3__net13 45.0049
rk2269 n5__i1__i1__net22 n6__i1__i1__net22 31.2572
rk2270 n6__i1__i1__net22 n7__i1__i1__net22 75.2527
rk2271 n6__i1__i1__net22 n3__i1__i1__net22 225.7e-3
rk2274 n5__i3__net12 n6__i3__net12 31.1958
rk2275 n6__i3__net12 n7__i3__net12 75.1571
rk2277 n779__vddio n781__vddio 29.7e-3
rk2278 n781__vddio n782__vddio 330.8e-3
rk2279 n782__vddio n783__vddio 338.1e-3
rk2280 n783__vddio n784__vddio 42.07e-3
rk2281 n784__vddio n785__vddio 316.6e-3
rk2282 n785__vddio n786__vddio 357.3e-3
rk2283 n786__vddio n787__vddio 39.59e-3
rk2284 n787__vddio n788__vddio 319.1e-3
rk2285 n788__vddio n789__vddio 338.1e-3
rk2286 n789__vddio n790__vddio 51.97e-3
rk2287 n790__vddio n791__vddio 389.7e-3
rk2288 n780__vddio n781__vddio 3.1
rk2289 n780__vddio n784__vddio 3.1
rk2290 n780__vddio n787__vddio 3.1
rk2291 n780__vddio n790__vddio 3.1
rk2292 n485__vss n486__vss 54.44e-3
rk2293 n486__vss n487__vss 360.5e-3
rk2294 n487__vss n488__vss 294.3e-3
rk2295 n488__vss n489__vss 42.07e-3
rk2296 n489__vss n490__vss 360.5e-3
rk2297 n490__vss n491__vss 185e-3
rk2298 n491__vss n492__vss 262e-3
rk2299 n484__vss n485__vss 3.75
rk2300 n484__vss n488__vss 3.75
rk2301 n484__vss n491__vss 5.7692
rk2302 n546__i0__i14__net1 n661__i0__i14__net1 125e-3
rk2303 n548__i0__i14__net1 n662__i0__i14__net1 125e-3
rk2304 i1__i1__net24 n2__i1__i1__net24 62.1818
rk2305 i1__i1__net25 n2__i1__i1__net25 150.192
rk2307 n1484__chipdriverout n1485__chipdriverout 12.37e-3
rk2308 n1485__chipdriverout n1486__chipdriverout 360.5e-3
rk2309 n1486__chipdriverout n1487__chipdriverout 223.4e-3
rk2310 n1487__chipdriverout n1488__chipdriverout 114.8e-3
rk2311 n1488__chipdriverout n1489__chipdriverout 360.5e-3
rk2312 n1489__chipdriverout n1490__chipdriverout 239.3e-3
rk2313 n1490__chipdriverout n1491__chipdriverout 118e-3
rk2315 n1483__chipdriverout n1484__chipdriverout 5.7692
rk2316 n1483__chipdriverout n1487__chipdriverout 3.75
rk2317 n1483__chipdriverout n1490__chipdriverout 3.75
rk2319 n1494__chipdriverout n1496__chipdriverout 207.4e-3
rk2320 n1496__chipdriverout n1497__chipdriverout 153.1e-3
rk2321 n1497__chipdriverout n1498__chipdriverout 338.1e-3
rk2322 n1498__chipdriverout n1499__chipdriverout 223.4e-3
rk2323 n1499__chipdriverout n1500__chipdriverout 137.1e-3
rk2324 n1500__chipdriverout n1501__chipdriverout 357.3e-3
rk2325 n1501__chipdriverout n1502__chipdriverout 220.2e-3
rk2326 n1502__chipdriverout n1503__chipdriverout 140.3e-3
rk2327 n1503__chipdriverout n1504__chipdriverout 338.1e-3
rk2328 n1504__chipdriverout n1505__chipdriverout 236.1e-3
rk2329 n1505__chipdriverout n1506__chipdriverout 124.4e-3
rk2331 n1495__chipdriverout n1496__chipdriverout 3.1
rk2332 n1495__chipdriverout n1499__chipdriverout 3.1
rk2333 n1495__chipdriverout n1502__chipdriverout 3.1
rk2334 n1495__chipdriverout n1505__chipdriverout 3.1
rk2336 n3__i3__net11 n6__i3__net11 502.4e-3
rk2337 n14__clk n27__clk 4.864e-3
rk2338 n12__i1__net1 n4__i1__net1 507.6e-3
rk2342 n800__vddio n802__vddio 29.7e-3
rk2343 n802__vddio n803__vddio 330.8e-3
rk2344 n803__vddio n804__vddio 338.1e-3
rk2345 n804__vddio n805__vddio 42.07e-3
rk2346 n805__vddio n806__vddio 316.6e-3
rk2347 n806__vddio n807__vddio 357.3e-3
rk2348 n807__vddio n808__vddio 39.59e-3
rk2349 n808__vddio n809__vddio 319.1e-3
rk2350 n809__vddio n810__vddio 338.1e-3
rk2351 n810__vddio n811__vddio 51.97e-3
rk2352 n811__vddio n812__vddio 389.7e-3
rk2353 n801__vddio n802__vddio 3.1
rk2354 n801__vddio n805__vddio 3.1
rk2355 n801__vddio n808__vddio 3.1
rk2356 n801__vddio n811__vddio 3.1
rk2357 n498__vss n499__vss 54.44e-3
rk2358 n499__vss n500__vss 360.5e-3
rk2359 n500__vss n501__vss 294.3e-3
rk2360 n501__vss n502__vss 42.07e-3
rk2361 n502__vss n503__vss 360.5e-3
rk2362 n503__vss n504__vss 185e-3
rk2363 n504__vss n505__vss 262e-3
rk2364 n497__vss n498__vss 3.75
rk2365 n497__vss n501__vss 3.75
rk2366 n497__vss n504__vss 5.7692
rk2367 n562__i0__i14__net1 n677__i0__i14__net1 125e-3
rk2368 n564__i0__i14__net1 n678__i0__i14__net1 125e-3
rk2369 i3__i1__net4 n2__i3__i1__net4 62.1818
rk2370 i3__i1__net1 n2__i3__i1__net1 150.192
rk2371 n2__reset n4__reset 76.06e-3
rk2372 n25__i3__net13 n8__i3__net13 505.2e-3
rk2373 n9__i3__net12 n2__i3__net12 505.2e-3
rk2375 n1536__chipdriverout n1537__chipdriverout 12.37e-3
rk2376 n1537__chipdriverout n1538__chipdriverout 360.5e-3
rk2377 n1538__chipdriverout n1539__chipdriverout 223.4e-3
rk2378 n1539__chipdriverout n1540__chipdriverout 114.8e-3
rk2379 n1540__chipdriverout n1541__chipdriverout 360.5e-3
rk2380 n1541__chipdriverout n1542__chipdriverout 239.3e-3
rk2381 n1542__chipdriverout n1543__chipdriverout 118e-3
rk2383 n1535__chipdriverout n1536__chipdriverout 5.7692
rk2384 n1535__chipdriverout n1539__chipdriverout 3.75
rk2385 n1535__chipdriverout n1542__chipdriverout 3.75
rk2387 n1546__chipdriverout n1548__chipdriverout 207.4e-3
rk2388 n1548__chipdriverout n1549__chipdriverout 153.1e-3
rk2389 n1549__chipdriverout n1550__chipdriverout 338.1e-3
rk2390 n1550__chipdriverout n1551__chipdriverout 223.4e-3
rk2391 n1551__chipdriverout n1552__chipdriverout 137.1e-3
rk2392 n1552__chipdriverout n1553__chipdriverout 357.3e-3
rk2393 n1553__chipdriverout n1554__chipdriverout 220.2e-3
rk2394 n1554__chipdriverout n1555__chipdriverout 140.3e-3
rk2395 n1555__chipdriverout n1556__chipdriverout 338.1e-3
rk2396 n1556__chipdriverout n1557__chipdriverout 236.1e-3
rk2397 n1557__chipdriverout n1558__chipdriverout 124.4e-3
rk2399 n1547__chipdriverout n1548__chipdriverout 3.1
rk2400 n1547__chipdriverout n1551__chipdriverout 3.1
rk2401 n1547__chipdriverout n1554__chipdriverout 3.1
rk2402 n1547__chipdriverout n1557__chipdriverout 3.1
rk2403 i1__net4 n2__i1__net4 19.278
rk2404 n2__i1__net4 n4__i1__net4 515.4e-3
rk2405 n4__i1__net4 n5__i1__net4 75.478
rk2406 n3__i1__net4 n4__i1__net4 31
rk2407 n574__i0__i14__net1 n681__i0__i14__net1 125e-3
rk2408 n576__i0__i14__net1 n682__i0__i14__net1 125e-3
rk2410 n821__vddio n823__vddio 29.7e-3
rk2411 n823__vddio n824__vddio 330.8e-3
rk2412 n824__vddio n825__vddio 338.1e-3
rk2413 n825__vddio n826__vddio 42.07e-3
rk2414 n826__vddio n827__vddio 316.6e-3
rk2415 n827__vddio n828__vddio 357.3e-3
rk2416 n828__vddio n829__vddio 39.59e-3
rk2417 n829__vddio n830__vddio 319.1e-3
rk2418 n830__vddio n831__vddio 338.1e-3
rk2419 n831__vddio n832__vddio 51.97e-3
rk2420 n832__vddio n833__vddio 389.7e-3
rk2421 n822__vddio n823__vddio 3.1
rk2422 n822__vddio n826__vddio 3.1
rk2423 n822__vddio n829__vddio 3.1
rk2424 n822__vddio n832__vddio 3.1
rk2425 n511__vss n512__vss 54.44e-3
rk2426 n512__vss n513__vss 360.5e-3
rk2427 n513__vss n514__vss 294.3e-3
rk2428 n514__vss n515__vss 42.07e-3
rk2429 n515__vss n516__vss 360.5e-3
rk2430 n516__vss n517__vss 185e-3
rk2431 n517__vss n518__vss 262e-3
rk2432 n510__vss n511__vss 3.75
rk2433 n510__vss n514__vss 3.75
rk2434 n510__vss n517__vss 5.7692
rk2435 n5__i3__i1__net2 n6__i3__i1__net2 31.2572
rk2436 n6__i3__i1__net2 n7__i3__i1__net2 75.2527
rk2437 n6__i3__i1__net2 n3__i3__i1__net2 225.7e-3
rk2438 n578__i0__i14__net1 n693__i0__i14__net1 125e-3
rk2439 n580__i0__i14__net1 n694__i0__i14__net1 125e-3
rk2441 n24__s n9__s 45.0049
rk2443 n1575__chipdriverout n1576__chipdriverout 12.37e-3
rk2444 n1576__chipdriverout n1577__chipdriverout 360.5e-3
rk2445 n1577__chipdriverout n1578__chipdriverout 223.4e-3
rk2446 n1578__chipdriverout n1579__chipdriverout 114.8e-3
rk2447 n1579__chipdriverout n1580__chipdriverout 360.5e-3
rk2448 n1580__chipdriverout n1581__chipdriverout 239.3e-3
rk2449 n1581__chipdriverout n1582__chipdriverout 118e-3
rk2451 n1574__chipdriverout n1575__chipdriverout 5.7692
rk2452 n1574__chipdriverout n1578__chipdriverout 3.75
rk2453 n1574__chipdriverout n1581__chipdriverout 3.75
rk2455 n1585__chipdriverout n1587__chipdriverout 207.4e-3
rk2456 n1587__chipdriverout n1588__chipdriverout 153.1e-3
rk2457 n1588__chipdriverout n1589__chipdriverout 338.1e-3
rk2458 n1589__chipdriverout n1590__chipdriverout 223.4e-3
rk2459 n1590__chipdriverout n1591__chipdriverout 137.1e-3
rk2460 n1591__chipdriverout n1592__chipdriverout 357.3e-3
rk2461 n1592__chipdriverout n1593__chipdriverout 220.2e-3
rk2462 n1593__chipdriverout n1594__chipdriverout 140.3e-3
rk2463 n1594__chipdriverout n1595__chipdriverout 338.1e-3
rk2464 n1595__chipdriverout n1596__chipdriverout 236.1e-3
rk2465 n1596__chipdriverout n1597__chipdriverout 124.4e-3
rk2467 n1586__chipdriverout n1587__chipdriverout 3.1
rk2468 n1586__chipdriverout n1590__chipdriverout 3.1
rk2469 n1586__chipdriverout n1593__chipdriverout 3.1
rk2470 n1586__chipdriverout n1596__chipdriverout 3.1
rk2471 n590__i0__i14__net1 n697__i0__i14__net1 125e-3
rk2472 n592__i0__i14__net1 n698__i0__i14__net1 125e-3
rk2473 i3__i1__net3 n2__i3__i1__net3 62.1818
rk2474 i3__i1__net5 n2__i3__i1__net5 150.192
rk2475 n9__i1__net4 n8__i1__net4 31.2141
rk2476 n8__i1__net4 n10__i1__net4 75.2406
rk2478 n842__vddio n844__vddio 29.7e-3
rk2479 n844__vddio n845__vddio 330.8e-3
rk2480 n845__vddio n846__vddio 338.1e-3
rk2481 n846__vddio n847__vddio 42.07e-3
rk2482 n847__vddio n848__vddio 316.6e-3
rk2483 n848__vddio n849__vddio 357.3e-3
rk2484 n849__vddio n850__vddio 39.59e-3
rk2485 n850__vddio n851__vddio 319.1e-3
rk2486 n851__vddio n852__vddio 338.1e-3
rk2487 n852__vddio n853__vddio 51.97e-3
rk2488 n853__vddio n854__vddio 389.7e-3
rk2489 n843__vddio n844__vddio 3.1
rk2490 n843__vddio n847__vddio 3.1
rk2491 n843__vddio n850__vddio 3.1
rk2492 n843__vddio n853__vddio 3.1
rk2493 n524__vss n525__vss 54.44e-3
rk2494 n525__vss n526__vss 360.5e-3
rk2495 n526__vss n527__vss 294.3e-3
rk2496 n527__vss n528__vss 42.07e-3
rk2497 n528__vss n529__vss 360.5e-3
rk2498 n529__vss n530__vss 185e-3
rk2499 n530__vss n531__vss 262e-3
rk2500 n523__vss n524__vss 3.75
rk2501 n523__vss n527__vss 3.75
rk2502 n523__vss n530__vss 5.7692
rk2503 n10__i3__net13 n27__i3__net13 4.864e-3
rk2504 n11__i3__net12 n4__i3__net12 7.591e-3
rk2505 n594__i0__i14__net1 n709__i0__i14__net1 125e-3
rk2506 n596__i0__i14__net1 n710__i0__i14__net1 125e-3
rk2508 n1613__chipdriverout n1615__chipdriverout 207.4e-3
rk2509 n1615__chipdriverout n1616__chipdriverout 153.1e-3
rk2510 n1616__chipdriverout n1617__chipdriverout 338.1e-3
rk2511 n1617__chipdriverout n1618__chipdriverout 223.4e-3
rk2512 n1618__chipdriverout n1619__chipdriverout 137.1e-3
rk2513 n1619__chipdriverout n1620__chipdriverout 357.3e-3
rk2514 n1620__chipdriverout n1621__chipdriverout 220.2e-3
rk2515 n1621__chipdriverout n1622__chipdriverout 140.3e-3
rk2516 n1622__chipdriverout n1623__chipdriverout 338.1e-3
rk2517 n1623__chipdriverout n1624__chipdriverout 236.1e-3
rk2518 n1624__chipdriverout n1625__chipdriverout 124.4e-3
rk2520 n1614__chipdriverout n1615__chipdriverout 3.1
rk2521 n1614__chipdriverout n1618__chipdriverout 3.1
rk2522 n1614__chipdriverout n1621__chipdriverout 3.1
rk2523 n1614__chipdriverout n1624__chipdriverout 3.1
rk2525 n1629__chipdriverout n1630__chipdriverout 12.37e-3
rk2526 n1630__chipdriverout n1631__chipdriverout 360.5e-3
rk2527 n1631__chipdriverout n1632__chipdriverout 223.4e-3
rk2528 n1632__chipdriverout n1633__chipdriverout 114.8e-3
rk2529 n1633__chipdriverout n1634__chipdriverout 360.5e-3
rk2530 n1634__chipdriverout n1635__chipdriverout 239.3e-3
rk2531 n1635__chipdriverout n1636__chipdriverout 118e-3
rk2533 n1628__chipdriverout n1629__chipdriverout 5.7692
rk2534 n1628__chipdriverout n1632__chipdriverout 3.75
rk2535 n1628__chipdriverout n1635__chipdriverout 3.75
rk2536 n602__i0__i14__net1 n717__i0__i14__net1 125e-3
rk2537 n604__i0__i14__net1 n718__i0__i14__net1 125e-3
rk2538 n4__r1 n2__r1 31.2292
rk2539 n2__r1 n5__r1 75.2548
rk2540 n4__i1__i10__net4 n6__i1__i10__net4 1.1698
rk2541 n6__i1__i10__net4 n8__i1__i10__net4 433.2e-3
rk2542 n8__i1__i10__net4 n2__i1__i10__net4 477.9e-3
rk2543 n5__i1__i10__net4 n6__i1__i10__net4 75
rk2544 n7__i1__i10__net4 n8__i1__i10__net4 31
rk2545 n19__s n27__s 1.2751
rk2546 n27__s n17__s 5.036e-3
rk2547 n8__clk4 n9__clk4 31.1276
rk2548 n9__clk4 n10__clk4 270.8e-3
rk2549 n10__clk4 n11__clk4 75.1117
rk2550 n9__clk4 n2__clk4 45.2612
rk2552 n862__vddio n878__vddio 29.7e-3
rk2553 n878__vddio n865__vddio 330.8e-3
rk2554 n865__vddio n866__vddio 338.1e-3
rk2555 n866__vddio n879__vddio 42.07e-3
rk2556 n879__vddio n869__vddio 316.6e-3
rk2557 n869__vddio n870__vddio 357.3e-3
rk2558 n870__vddio n880__vddio 39.59e-3
rk2559 n880__vddio n873__vddio 319.1e-3
rk2560 n873__vddio n874__vddio 338.1e-3
rk2561 n874__vddio n881__vddio 51.97e-3
rk2562 n881__vddio n882__vddio 389.7e-3
rk2563 n877__vddio n878__vddio 3.1
rk2564 n877__vddio n879__vddio 3.1
rk2565 n877__vddio n880__vddio 3.1
rk2566 n877__vddio n881__vddio 3.1
rk2567 n545__vss n543__vss 54.44e-3
rk2568 n543__vss n540__vss 360.5e-3
rk2569 n540__vss n546__vss 294.3e-3
rk2570 n546__vss n539__vss 42.07e-3
rk2571 n539__vss n536__vss 360.5e-3
rk2572 n536__vss n547__vss 185e-3
rk2573 n547__vss n548__vss 262e-3
rk2574 n544__vss n545__vss 3.75
rk2575 n544__vss n546__vss 3.75
rk2576 n544__vss n547__vss 5.7692
rk2577 n5__i1__net5 n6__i1__net5 75.2339
rk2578 n6__i1__net5 n8__i1__net5 211.2e-3
rk2579 n8__i1__net5 n10__i1__net5 1.0822
rk2580 n10__i1__net5 n11__i1__net5 75.5164
rk2581 n7__i1__net5 n8__i1__net5 31
rk2582 n9__i1__net5 n10__i1__net5 31
rk2583 n8__i3__net11 n9__i3__net11 31.3327
rk2584 n9__i3__net11 n10__i3__net11 75.0212
rk2585 n610__i0__i14__net1 n721__i0__i14__net1 125e-3
rk2586 n612__i0__i14__net1 n722__i0__i14__net1 125e-3
rk2588 n1652__chipdriverout n1654__chipdriverout 207.4e-3
rk2589 n1654__chipdriverout n1655__chipdriverout 153.1e-3
rk2590 n1655__chipdriverout n1656__chipdriverout 338.1e-3
rk2591 n1656__chipdriverout n1657__chipdriverout 223.4e-3
rk2592 n1657__chipdriverout n1658__chipdriverout 137.1e-3
rk2593 n1658__chipdriverout n1659__chipdriverout 357.3e-3
rk2594 n1659__chipdriverout n1660__chipdriverout 220.2e-3
rk2595 n1660__chipdriverout n1661__chipdriverout 140.3e-3
rk2596 n1661__chipdriverout n1662__chipdriverout 338.1e-3
rk2597 n1662__chipdriverout n1663__chipdriverout 236.1e-3
rk2598 n1663__chipdriverout n1664__chipdriverout 124.4e-3
rk2600 n1653__chipdriverout n1654__chipdriverout 3.1
rk2601 n1653__chipdriverout n1657__chipdriverout 3.1
rk2602 n1653__chipdriverout n1660__chipdriverout 3.1
rk2603 n1653__chipdriverout n1663__chipdriverout 3.1
rk2605 n1668__chipdriverout n1669__chipdriverout 12.37e-3
rk2606 n1669__chipdriverout n1670__chipdriverout 360.5e-3
rk2607 n1670__chipdriverout n1671__chipdriverout 223.4e-3
rk2608 n1671__chipdriverout n1672__chipdriverout 114.8e-3
rk2609 n1672__chipdriverout n1673__chipdriverout 360.5e-3
rk2610 n1673__chipdriverout n1674__chipdriverout 239.3e-3
rk2611 n1674__chipdriverout n1675__chipdriverout 118e-3
rk2613 n1667__chipdriverout n1668__chipdriverout 5.7692
rk2614 n1667__chipdriverout n1671__chipdriverout 3.75
rk2615 n1667__chipdriverout n1674__chipdriverout 3.75
rk2616 n618__i0__i14__net1 n725__i0__i14__net1 125e-3
rk2617 n620__i0__i14__net1 n726__i0__i14__net1 125e-3
rk2618 n6__clk4 n15__clk4 500e-3
rk2620 n14__i1__net5 n3__i1__net5 4.864e-3
rk2622 n884__vddio n886__vddio 29.7e-3
rk2623 n886__vddio n887__vddio 330.8e-3
rk2624 n887__vddio n888__vddio 338.1e-3
rk2625 n888__vddio n889__vddio 42.07e-3
rk2626 n889__vddio n890__vddio 316.6e-3
rk2627 n890__vddio n891__vddio 357.3e-3
rk2628 n891__vddio n892__vddio 39.59e-3
rk2629 n892__vddio n893__vddio 319.1e-3
rk2630 n893__vddio n894__vddio 338.1e-3
rk2631 n894__vddio n895__vddio 51.97e-3
rk2632 n895__vddio n896__vddio 389.7e-3
rk2633 n885__vddio n886__vddio 3.1
rk2634 n885__vddio n889__vddio 3.1
rk2635 n885__vddio n892__vddio 3.1
rk2636 n885__vddio n895__vddio 3.1
rk2637 n550__vss n551__vss 54.44e-3
rk2638 n551__vss n552__vss 360.5e-3
rk2639 n552__vss n553__vss 294.3e-3
rk2640 n553__vss n554__vss 42.07e-3
rk2641 n554__vss n555__vss 360.5e-3
rk2642 n555__vss n556__vss 185e-3
rk2643 n556__vss n557__vss 262e-3
rk2644 n549__vss n550__vss 3.75
rk2645 n549__vss n553__vss 3.75
rk2646 n549__vss n556__vss 5.7692
rk2647 n13__i3__net13 n28__i3__net13 502.4e-3
rk2648 n626__i0__i14__net1 n727__i0__i14__net1 125e-3
rk2649 n628__i0__i14__net1 n728__i0__i14__net1 125e-3
rk2651 n1691__chipdriverout n1693__chipdriverout 207.4e-3
rk2652 n1693__chipdriverout n1694__chipdriverout 153.1e-3
rk2653 n1694__chipdriverout n1695__chipdriverout 338.1e-3
rk2654 n1695__chipdriverout n1696__chipdriverout 223.4e-3
rk2655 n1696__chipdriverout n1697__chipdriverout 137.1e-3
rk2656 n1697__chipdriverout n1698__chipdriverout 357.3e-3
rk2657 n1698__chipdriverout n1699__chipdriverout 220.2e-3
rk2658 n1699__chipdriverout n1700__chipdriverout 140.3e-3
rk2659 n1700__chipdriverout n1701__chipdriverout 338.1e-3
rk2660 n1701__chipdriverout n1702__chipdriverout 236.1e-3
rk2661 n1702__chipdriverout n1703__chipdriverout 124.4e-3
rk2663 n1692__chipdriverout n1693__chipdriverout 3.1
rk2664 n1692__chipdriverout n1696__chipdriverout 3.1
rk2665 n1692__chipdriverout n1699__chipdriverout 3.1
rk2666 n1692__chipdriverout n1702__chipdriverout 3.1
rk2668 n1707__chipdriverout n1708__chipdriverout 12.37e-3
rk2669 n1708__chipdriverout n1709__chipdriverout 360.5e-3
rk2670 n1709__chipdriverout n1710__chipdriverout 223.4e-3
rk2671 n1710__chipdriverout n1711__chipdriverout 114.8e-3
rk2672 n1711__chipdriverout n1712__chipdriverout 360.5e-3
rk2673 n1712__chipdriverout n1713__chipdriverout 239.3e-3
rk2674 n1713__chipdriverout n1714__chipdriverout 118e-3
rk2676 n1706__chipdriverout n1707__chipdriverout 5.7692
rk2677 n1706__chipdriverout n1710__chipdriverout 3.75
rk2678 n1706__chipdriverout n1713__chipdriverout 3.75
rk2679 i1__i2__net21 n2__i1__i2__net21 62.1818
rk2680 i1__i2__net23 n2__i1__i2__net23 150.192
rk2681 n634__i0__i14__net1 n733__i0__i14__net1 125e-3
rk2682 n636__i0__i14__net1 n734__i0__i14__net1 125e-3
rk2683 n33__clk n25__clk 505.2e-3
rk2684 n18__i1__net1 n10__i1__net1 505.2e-3
rk2686 n905__vddio n907__vddio 29.7e-3
rk2687 n907__vddio n908__vddio 330.8e-3
rk2688 n908__vddio n909__vddio 338.1e-3
rk2689 n909__vddio n910__vddio 42.07e-3
rk2690 n910__vddio n911__vddio 316.6e-3
rk2691 n911__vddio n912__vddio 357.3e-3
rk2692 n912__vddio n913__vddio 39.59e-3
rk2693 n913__vddio n914__vddio 319.1e-3
rk2694 n914__vddio n915__vddio 338.1e-3
rk2695 n915__vddio n916__vddio 51.97e-3
rk2696 n916__vddio n917__vddio 389.7e-3
rk2697 n906__vddio n907__vddio 3.1
rk2698 n906__vddio n910__vddio 3.1
rk2699 n906__vddio n913__vddio 3.1
rk2700 n906__vddio n916__vddio 3.1
rk2701 n563__vss n564__vss 54.44e-3
rk2702 n564__vss n565__vss 360.5e-3
rk2703 n565__vss n566__vss 294.3e-3
rk2704 n566__vss n567__vss 42.07e-3
rk2705 n567__vss n568__vss 360.5e-3
rk2706 n568__vss n569__vss 185e-3
rk2707 n569__vss n570__vss 262e-3
rk2708 n562__vss n563__vss 3.75
rk2709 n562__vss n566__vss 3.75
rk2710 n562__vss n569__vss 5.7692
rk2711 n4__i3__i6__net1 n5__i3__i6__net1 15.7997
rk2712 n5__i3__i6__net1 n6__i3__i6__net1 75.3498
rk2713 n5__i3__i6__net1 n2__i3__i6__net1 45.3257
rk2714 n646__i0__i14__net1 n735__i0__i14__net1 125e-3
rk2715 n648__i0__i14__net1 n736__i0__i14__net1 125e-3
rk2717 n572__vss n574__vss 156.5e-3
rk2718 n574__vss n575__vss 57.93e-3
rk2719 n575__vss n576__vss 206.8e-3
rk2720 n576__vss n577__vss 262.6e-3
rk2721 n577__vss n578__vss 55.4e-3
rk2722 n578__vss n579__vss 611.2e-3
rk2723 n579__vss n580__vss 75.62e-3
rk2724 n580__vss n581__vss 515.4e-3
rk2725 n581__vss n582__vss 287.9e-3
rk2726 n582__vss n583__vss 55.4e-3
rk2727 n583__vss n584__vss 239.9e-3
rk2728 n584__vss n585__vss 55.4e-3
rk2729 n585__vss n586__vss 611.2e-3
rk2730 n586__vss n587__vss 75.62e-3
rk2731 n587__vss n588__vss 515.4e-3
rk2732 n588__vss n418__vss 267.3e-3
rk2733 n418__vss n589__vss 17.02e-3
rk2734 n589__vss n590__vss 75.6669
rk2735 n572__vss n591__vss 75.3637
rk2736 n575__vss n592__vss 75.3496
rk2737 n576__vss n593__vss 75.3496
rk2738 n578__vss n594__vss 75.6163
rk2739 n579__vss n595__vss 75.4081
rk2740 n581__vss n596__vss 75.4081
rk2741 n583__vss n597__vss 75.6163
rk2742 n585__vss n598__vss 75.6163
rk2743 n586__vss n599__vss 75.4081
rk2744 n588__vss n600__vss 75.4081
rk2745 n573__vss n574__vss 6.2
rk2746 n573__vss n577__vss 20.6667
rk2747 n573__vss n580__vss 3.4444
rk2748 n573__vss n582__vss 20.6667
rk2749 n573__vss n584__vss 20.6667
rk2750 n573__vss n587__vss 3.4444
rk2751 n573__vss n589__vss 20.6667
rk2752 n35__s n33__s 31.2052
rk2753 n33__s n36__s 75.1596
rk2755 n1740__chipdriverout n1757__chipdriverout 207.4e-3
rk2756 n1757__chipdriverout n1741__chipdriverout 153.1e-3
rk2757 n1741__chipdriverout n1744__chipdriverout 338.1e-3
rk2758 n1744__chipdriverout n1758__chipdriverout 223.4e-3
rk2759 n1758__chipdriverout n1745__chipdriverout 137.1e-3
rk2760 n1745__chipdriverout n1748__chipdriverout 357.3e-3
rk2761 n1748__chipdriverout n1759__chipdriverout 220.2e-3
rk2762 n1759__chipdriverout n1749__chipdriverout 140.3e-3
rk2763 n1749__chipdriverout n1752__chipdriverout 338.1e-3
rk2764 n1752__chipdriverout n1760__chipdriverout 236.1e-3
rk2765 n1760__chipdriverout n1753__chipdriverout 124.4e-3
rk2767 n1756__chipdriverout n1757__chipdriverout 3.1
rk2768 n1756__chipdriverout n1758__chipdriverout 3.1
rk2769 n1756__chipdriverout n1759__chipdriverout 3.1
rk2770 n1756__chipdriverout n1760__chipdriverout 3.1
rk2772 n1764__chipdriverout n1729__chipdriverout 12.37e-3
rk2773 n1729__chipdriverout n1732__chipdriverout 360.5e-3
rk2774 n1732__chipdriverout n1765__chipdriverout 223.4e-3
rk2775 n1765__chipdriverout n1733__chipdriverout 114.8e-3
rk2776 n1733__chipdriverout n1736__chipdriverout 360.5e-3
rk2777 n1736__chipdriverout n1766__chipdriverout 239.3e-3
rk2778 n1766__chipdriverout n1737__chipdriverout 118e-3
rk2780 n1763__chipdriverout n1764__chipdriverout 5.7692
rk2781 n1763__chipdriverout n1765__chipdriverout 3.75
rk2782 n1763__chipdriverout n1766__chipdriverout 3.75
rk2783 n5__i1__i2__net22 n6__i1__i2__net22 31.2572
rk2784 n6__i1__i2__net22 n7__i1__i2__net22 75.2527
rk2785 n6__i1__i2__net22 n3__i1__i2__net22 225.7e-3
rk2789 n926__vddio n928__vddio 29.7e-3
rk2790 n928__vddio n929__vddio 330.8e-3
rk2791 n929__vddio n930__vddio 338.1e-3
rk2792 n930__vddio n931__vddio 42.07e-3
rk2793 n931__vddio n932__vddio 316.6e-3
rk2794 n932__vddio n933__vddio 357.3e-3
rk2795 n933__vddio n934__vddio 39.59e-3
rk2796 n934__vddio n935__vddio 319.1e-3
rk2797 n935__vddio n936__vddio 338.1e-3
rk2798 n936__vddio n937__vddio 51.97e-3
rk2799 n937__vddio n938__vddio 389.7e-3
rk2800 n927__vddio n928__vddio 3.1
rk2801 n927__vddio n931__vddio 3.1
rk2802 n927__vddio n934__vddio 3.1
rk2803 n927__vddio n937__vddio 3.1
rk2804 n606__vss n607__vss 54.44e-3
rk2805 n607__vss n608__vss 360.5e-3
rk2806 n608__vss n609__vss 294.3e-3
rk2807 n609__vss n610__vss 42.07e-3
rk2808 n610__vss n611__vss 360.5e-3
rk2809 n611__vss n612__vss 185e-3
rk2810 n612__vss n613__vss 262e-3
rk2811 n605__vss n606__vss 3.75
rk2812 n605__vss n609__vss 3.75
rk2813 n605__vss n612__vss 5.7692
rk2814 n658__i0__i14__net1 n745__i0__i14__net1 125e-3
rk2815 n660__i0__i14__net1 n746__i0__i14__net1 125e-3
rk2816 i1__i2__net24 n2__i1__i2__net24 62.1818
rk2817 i1__i2__net25 n2__i1__i2__net25 150.192
rk2818 n30__clk n34__clk 4.864e-3
rk2819 n19__i1__net1 n15__i1__net1 7.591e-3
rk2821 n1769__chipdriverout n1771__chipdriverout 207.4e-3
rk2822 n1771__chipdriverout n1772__chipdriverout 153.1e-3
rk2823 n1772__chipdriverout n1773__chipdriverout 338.1e-3
rk2824 n1773__chipdriverout n1774__chipdriverout 223.4e-3
rk2825 n1774__chipdriverout n1775__chipdriverout 137.1e-3
rk2826 n1775__chipdriverout n1776__chipdriverout 357.3e-3
rk2827 n1776__chipdriverout n1777__chipdriverout 220.2e-3
rk2828 n1777__chipdriverout n1778__chipdriverout 140.3e-3
rk2829 n1778__chipdriverout n1779__chipdriverout 338.1e-3
rk2830 n1779__chipdriverout n1780__chipdriverout 236.1e-3
rk2831 n1780__chipdriverout n1781__chipdriverout 124.4e-3
rk2833 n1770__chipdriverout n1771__chipdriverout 3.1
rk2834 n1770__chipdriverout n1774__chipdriverout 3.1
rk2835 n1770__chipdriverout n1777__chipdriverout 3.1
rk2836 n1770__chipdriverout n1780__chipdriverout 3.1
rk2838 n1785__chipdriverout n1786__chipdriverout 12.37e-3
rk2839 n1786__chipdriverout n1787__chipdriverout 360.5e-3
rk2840 n1787__chipdriverout n1788__chipdriverout 223.4e-3
rk2841 n1788__chipdriverout n1789__chipdriverout 114.8e-3
rk2842 n1789__chipdriverout n1790__chipdriverout 360.5e-3
rk2843 n1790__chipdriverout n1791__chipdriverout 239.3e-3
rk2844 n1791__chipdriverout n1792__chipdriverout 118e-3
rk2846 n1784__chipdriverout n1785__chipdriverout 5.7692
rk2847 n1784__chipdriverout n1788__chipdriverout 3.75
rk2848 n1784__chipdriverout n1791__chipdriverout 3.75
rk2852 n946__vddio n962__vddio 29.7e-3
rk2853 n962__vddio n949__vddio 330.8e-3
rk2854 n949__vddio n950__vddio 338.1e-3
rk2855 n950__vddio n963__vddio 42.07e-3
rk2856 n963__vddio n953__vddio 316.6e-3
rk2857 n953__vddio n954__vddio 357.3e-3
rk2858 n954__vddio n964__vddio 39.59e-3
rk2859 n964__vddio n957__vddio 319.1e-3
rk2860 n957__vddio n958__vddio 338.1e-3
rk2861 n958__vddio n965__vddio 51.97e-3
rk2862 n965__vddio n966__vddio 389.7e-3
rk2863 n961__vddio n962__vddio 3.1
rk2864 n961__vddio n963__vddio 3.1
rk2865 n961__vddio n964__vddio 3.1
rk2866 n961__vddio n965__vddio 3.1
rk2867 n639__vss n631__vss 54.44e-3
rk2868 n631__vss n628__vss 360.5e-3
rk2869 n628__vss n640__vss 294.3e-3
rk2870 n640__vss n627__vss 42.07e-3
rk2871 n627__vss n624__vss 360.5e-3
rk2872 n624__vss n641__vss 185e-3
rk2873 n641__vss n642__vss 262e-3
rk2874 n638__vss n639__vss 3.75
rk2875 n638__vss n640__vss 3.75
rk2876 n638__vss n641__vss 5.7692
rk2877 n674__i0__i14__net1 n753__i0__i14__net1 125e-3
rk2878 n676__i0__i14__net1 n754__i0__i14__net1 125e-3
rk2879 n7__reset n9__reset 76.06e-3
rk2881 n1819__chipdriverout n1808__chipdriverout 12.37e-3
rk2882 n1808__chipdriverout n1809__chipdriverout 360.5e-3
rk2883 n1809__chipdriverout n1820__chipdriverout 223.4e-3
rk2884 n1820__chipdriverout n1812__chipdriverout 114.8e-3
rk2885 n1812__chipdriverout n1813__chipdriverout 360.5e-3
rk2886 n1813__chipdriverout n1821__chipdriverout 239.3e-3
rk2887 n1821__chipdriverout n1816__chipdriverout 118e-3
rk2889 n1818__chipdriverout n1819__chipdriverout 5.7692
rk2890 n1818__chipdriverout n1820__chipdriverout 3.75
rk2891 n1818__chipdriverout n1821__chipdriverout 3.75
rk2893 n1824__chipdriverout n1826__chipdriverout 207.4e-3
rk2894 n1826__chipdriverout n1827__chipdriverout 153.1e-3
rk2895 n1827__chipdriverout n1828__chipdriverout 338.1e-3
rk2896 n1828__chipdriverout n1829__chipdriverout 223.4e-3
rk2897 n1829__chipdriverout n1830__chipdriverout 137.1e-3
rk2898 n1830__chipdriverout n1831__chipdriverout 357.3e-3
rk2899 n1831__chipdriverout n1832__chipdriverout 220.2e-3
rk2900 n1832__chipdriverout n1833__chipdriverout 140.3e-3
rk2901 n1833__chipdriverout n1834__chipdriverout 338.1e-3
rk2902 n1834__chipdriverout n1835__chipdriverout 236.1e-3
rk2903 n1835__chipdriverout n1836__chipdriverout 124.4e-3
rk2905 n1825__chipdriverout n1826__chipdriverout 3.1
rk2906 n1825__chipdriverout n1829__chipdriverout 3.1
rk2907 n1825__chipdriverout n1832__chipdriverout 3.1
rk2908 n1825__chipdriverout n1835__chipdriverout 3.1
rk2909 i1__net6 n2__i1__net6 19.278
rk2910 n2__i1__net6 n4__i1__net6 515.4e-3
rk2911 n4__i1__net6 n5__i1__net6 75.478
rk2912 n3__i1__net6 n4__i1__net6 31
rk2913 n686__i0__i14__net1 n757__i0__i14__net1 125e-3
rk2914 n688__i0__i14__net1 n758__i0__i14__net1 125e-3
rk2916 n968__vddio n983__vddio 29.7e-3
rk2917 n983__vddio n969__vddio 330.8e-3
rk2918 n969__vddio n972__vddio 338.1e-3
rk2919 n972__vddio n984__vddio 42.07e-3
rk2920 n984__vddio n973__vddio 316.6e-3
rk2921 n973__vddio n976__vddio 357.3e-3
rk2922 n976__vddio n985__vddio 39.59e-3
rk2923 n985__vddio n977__vddio 319.1e-3
rk2924 n977__vddio n980__vddio 338.1e-3
rk2925 n980__vddio n986__vddio 51.97e-3
rk2926 n986__vddio n987__vddio 389.7e-3
rk2927 n982__vddio n983__vddio 3.1
rk2928 n982__vddio n984__vddio 3.1
rk2929 n982__vddio n985__vddio 3.1
rk2930 n982__vddio n986__vddio 3.1
rk2931 n663__vss n660__vss 54.44e-3
rk2932 n660__vss n659__vss 360.5e-3
rk2933 n659__vss n664__vss 294.3e-3
rk2934 n664__vss n656__vss 42.07e-3
rk2935 n656__vss n655__vss 360.5e-3
rk2936 n655__vss n665__vss 185e-3
rk2937 n665__vss n666__vss 262e-3
rk2938 n662__vss n663__vss 3.75
rk2939 n662__vss n664__vss 3.75
rk2940 n662__vss n665__vss 5.7692
rk2942 n40__s n21__s 45.0049
rk2946 n1847__chipdriverout n1849__chipdriverout 207.4e-3
rk2947 n1849__chipdriverout n1850__chipdriverout 153.1e-3
rk2948 n1850__chipdriverout n1851__chipdriverout 338.1e-3
rk2949 n1851__chipdriverout n1852__chipdriverout 223.4e-3
rk2950 n1852__chipdriverout n1853__chipdriverout 137.1e-3
rk2951 n1853__chipdriverout n1854__chipdriverout 357.3e-3
rk2952 n1854__chipdriverout n1855__chipdriverout 220.2e-3
rk2953 n1855__chipdriverout n1856__chipdriverout 140.3e-3
rk2954 n1856__chipdriverout n1857__chipdriverout 338.1e-3
rk2955 n1857__chipdriverout n1858__chipdriverout 236.1e-3
rk2956 n1858__chipdriverout n1859__chipdriverout 124.4e-3
rk2958 n1848__chipdriverout n1849__chipdriverout 3.1
rk2959 n1848__chipdriverout n1852__chipdriverout 3.1
rk2960 n1848__chipdriverout n1855__chipdriverout 3.1
rk2961 n1848__chipdriverout n1858__chipdriverout 3.1
rk2963 n1863__chipdriverout n1864__chipdriverout 12.37e-3
rk2964 n1864__chipdriverout n1865__chipdriverout 360.5e-3
rk2965 n1865__chipdriverout n1866__chipdriverout 223.4e-3
rk2966 n1866__chipdriverout n1867__chipdriverout 114.8e-3
rk2967 n1867__chipdriverout n1868__chipdriverout 360.5e-3
rk2968 n1868__chipdriverout n1869__chipdriverout 239.3e-3
rk2969 n1869__chipdriverout n1870__chipdriverout 118e-3
rk2971 n1862__chipdriverout n1863__chipdriverout 5.7692
rk2972 n1862__chipdriverout n1866__chipdriverout 3.75
rk2973 n1862__chipdriverout n1869__chipdriverout 3.75
rk2976 n8__i1__net6 n9__i1__net6 31.2141
rk2977 n9__i1__net6 n10__i1__net6 75.2406
rk2979 n989__vddio n991__vddio 29.7e-3
rk2980 n991__vddio n992__vddio 330.8e-3
rk2981 n992__vddio n993__vddio 338.1e-3
rk2982 n993__vddio n994__vddio 42.07e-3
rk2983 n994__vddio n995__vddio 316.6e-3
rk2984 n995__vddio n996__vddio 357.3e-3
rk2985 n996__vddio n997__vddio 39.59e-3
rk2986 n997__vddio n998__vddio 319.1e-3
rk2987 n998__vddio n999__vddio 338.1e-3
rk2988 n999__vddio n1000__vddio 51.97e-3
rk2989 n1000__vddio n1001__vddio 389.7e-3
rk2990 n990__vddio n991__vddio 3.1
rk2991 n990__vddio n994__vddio 3.1
rk2992 n990__vddio n997__vddio 3.1
rk2993 n990__vddio n1000__vddio 3.1
rk2994 n668__vss n669__vss 54.44e-3
rk2995 n669__vss n670__vss 360.5e-3
rk2996 n670__vss n671__vss 294.3e-3
rk2997 n671__vss n672__vss 42.07e-3
rk2998 n672__vss n673__vss 360.5e-3
rk2999 n673__vss n674__vss 185e-3
rk3000 n674__vss n675__vss 262e-3
rk3001 n667__vss n668__vss 3.75
rk3002 n667__vss n671__vss 3.75
rk3003 n667__vss n674__vss 5.7692
rk3004 n706__i0__i14__net1 n769__i0__i14__net1 125e-3
rk3005 n708__i0__i14__net1 n770__i0__i14__net1 125e-3
rk3007 n1886__chipdriverout n1888__chipdriverout 207.4e-3
rk3008 n1888__chipdriverout n1889__chipdriverout 153.1e-3
rk3009 n1889__chipdriverout n1890__chipdriverout 338.1e-3
rk3010 n1890__chipdriverout n1891__chipdriverout 223.4e-3
rk3011 n1891__chipdriverout n1892__chipdriverout 137.1e-3
rk3012 n1892__chipdriverout n1893__chipdriverout 357.3e-3
rk3013 n1893__chipdriverout n1894__chipdriverout 220.2e-3
rk3014 n1894__chipdriverout n1895__chipdriverout 140.3e-3
rk3015 n1895__chipdriverout n1896__chipdriverout 338.1e-3
rk3016 n1896__chipdriverout n1897__chipdriverout 236.1e-3
rk3017 n1897__chipdriverout n1898__chipdriverout 124.4e-3
rk3019 n1887__chipdriverout n1888__chipdriverout 3.1
rk3020 n1887__chipdriverout n1891__chipdriverout 3.1
rk3021 n1887__chipdriverout n1894__chipdriverout 3.1
rk3022 n1887__chipdriverout n1897__chipdriverout 3.1
rk3024 n1902__chipdriverout n1903__chipdriverout 12.37e-3
rk3025 n1903__chipdriverout n1904__chipdriverout 360.5e-3
rk3026 n1904__chipdriverout n1905__chipdriverout 223.4e-3
rk3027 n1905__chipdriverout n1906__chipdriverout 114.8e-3
rk3028 n1906__chipdriverout n1907__chipdriverout 360.5e-3
rk3029 n1907__chipdriverout n1908__chipdriverout 239.3e-3
rk3030 n1908__chipdriverout n1909__chipdriverout 118e-3
rk3032 n1901__chipdriverout n1902__chipdriverout 5.7692
rk3033 n1901__chipdriverout n1905__chipdriverout 3.75
rk3034 n1901__chipdriverout n1908__chipdriverout 3.75
rk3037 n1__r0 n2__r0 31.2292
rk3038 n2__r0 n3__r0 75.2548
rk3039 n4__i1__i11__net4 n6__i1__i11__net4 1.1698
rk3040 n6__i1__i11__net4 n8__i1__i11__net4 433.2e-3
rk3041 n8__i1__i11__net4 n2__i1__i11__net4 477.9e-3
rk3042 n5__i1__i11__net4 n6__i1__i11__net4 75
rk3043 n7__i1__i11__net4 n8__i1__i11__net4 31
rk3044 n31__s n42__s 1.2751
rk3045 n42__s n29__s 5.036e-3
rk3047 n1010__vddio n1012__vddio 29.7e-3
rk3048 n1012__vddio n1013__vddio 330.8e-3
rk3049 n1013__vddio n1014__vddio 338.1e-3
rk3050 n1014__vddio n1015__vddio 42.07e-3
rk3051 n1015__vddio n1016__vddio 316.6e-3
rk3052 n1016__vddio n1017__vddio 357.3e-3
rk3053 n1017__vddio n1018__vddio 39.59e-3
rk3054 n1018__vddio n1019__vddio 319.1e-3
rk3055 n1019__vddio n1020__vddio 338.1e-3
rk3056 n1020__vddio n1021__vddio 51.97e-3
rk3057 n1021__vddio n1022__vddio 389.7e-3
rk3058 n1011__vddio n1012__vddio 3.1
rk3059 n1011__vddio n1015__vddio 3.1
rk3060 n1011__vddio n1018__vddio 3.1
rk3061 n1011__vddio n1021__vddio 3.1
rk3062 n681__vss n682__vss 54.44e-3
rk3063 n682__vss n683__vss 360.5e-3
rk3064 n683__vss n684__vss 294.3e-3
rk3065 n684__vss n685__vss 42.07e-3
rk3066 n685__vss n686__vss 360.5e-3
rk3067 n686__vss n687__vss 185e-3
rk3068 n687__vss n688__vss 262e-3
rk3069 n680__vss n681__vss 3.75
rk3070 n680__vss n684__vss 3.75
rk3071 n680__vss n687__vss 5.7692
rk3072 n5__i1__net7 n6__i1__net7 75.2339
rk3073 n6__i1__net7 n8__i1__net7 211.2e-3
rk3074 n8__i1__net7 n10__i1__net7 1.0822
rk3075 n10__i1__net7 n11__i1__net7 75.5164
rk3076 n7__i1__net7 n8__i1__net7 31
rk3077 n9__i1__net7 n10__i1__net7 31
rk3079 n14__i1__net7 n3__i1__net7 4.864e-3
rk3080 i1__i3__net21 n2__i1__i3__net21 62.1818
rk3081 i1__i3__net23 n2__i1__i3__net23 150.192
rk3082 n38__clk n32__clk 505.2e-3
rk3083 n23__i1__net1 n17__i1__net1 505.2e-3
rk3084 n5__i1__i3__net22 n6__i1__i3__net22 31.2572
rk3085 n6__i1__i3__net22 n7__i1__i3__net22 75.2527
rk3086 n6__i1__i3__net22 n3__i1__i3__net22 225.7e-3
rk3088 n1080__vddio n1082__vddio 29.7e-3
rk3089 n1082__vddio n1083__vddio 330.8e-3
rk3090 n1083__vddio n1084__vddio 338.1e-3
rk3091 n1084__vddio n1085__vddio 42.07e-3
rk3092 n1085__vddio n1086__vddio 316.6e-3
rk3093 n1086__vddio n1087__vddio 357.3e-3
rk3094 n1087__vddio n1088__vddio 39.59e-3
rk3095 n1088__vddio n1089__vddio 319.1e-3
rk3096 n1089__vddio n1090__vddio 338.1e-3
rk3097 n1090__vddio n1091__vddio 51.97e-3
rk3098 n1091__vddio n1092__vddio 389.7e-3
rk3099 n1081__vddio n1082__vddio 3.1
rk3100 n1081__vddio n1085__vddio 3.1
rk3101 n1081__vddio n1088__vddio 3.1
rk3102 n1081__vddio n1091__vddio 3.1
rk3103 n743__vss n744__vss 54.44e-3
rk3104 n744__vss n745__vss 360.5e-3
rk3105 n745__vss n746__vss 294.3e-3
rk3106 n746__vss n747__vss 42.07e-3
rk3107 n747__vss n748__vss 360.5e-3
rk3108 n748__vss n749__vss 185e-3
rk3109 n749__vss n750__vss 262e-3
rk3110 n742__vss n743__vss 3.75
rk3111 n742__vss n746__vss 3.75
rk3112 n742__vss n749__vss 5.7692
rk3113 i1__i3__net24 n2__i1__i3__net24 62.1818
rk3114 i1__i3__net25 n2__i1__i3__net25 150.192
rk3115 n37__clk n41__clk 4.864e-3
rk3116 n26__i1__net1 n22__i1__net1 7.591e-3
rk3117 i0__net2 n61__i0__net2 125e-3
rk3118 n3__i0__net2 n62__i0__net2 125e-3
rk3120 n780__i0__i14__net1 n781__i0__i14__net1 12.37e-3
rk3121 n781__i0__i14__net1 n782__i0__i14__net1 360.5e-3
rk3122 n782__i0__i14__net1 n783__i0__i14__net1 223.4e-3
rk3123 n783__i0__i14__net1 n784__i0__i14__net1 114.8e-3
rk3124 n784__i0__i14__net1 n785__i0__i14__net1 360.5e-3
rk3125 n785__i0__i14__net1 n786__i0__i14__net1 239.3e-3
rk3126 n786__i0__i14__net1 n787__i0__i14__net1 118e-3
rk3128 n779__i0__i14__net1 n780__i0__i14__net1 5.7692
rk3129 n779__i0__i14__net1 n783__i0__i14__net1 3.75
rk3130 n779__i0__i14__net1 n786__i0__i14__net1 3.75
rk3132 n790__i0__i14__net1 n792__i0__i14__net1 207.4e-3
rk3133 n792__i0__i14__net1 n793__i0__i14__net1 153.1e-3
rk3134 n793__i0__i14__net1 n794__i0__i14__net1 338.1e-3
rk3135 n794__i0__i14__net1 n795__i0__i14__net1 223.4e-3
rk3136 n795__i0__i14__net1 n796__i0__i14__net1 137.1e-3
rk3137 n796__i0__i14__net1 n797__i0__i14__net1 357.3e-3
rk3138 n797__i0__i14__net1 n798__i0__i14__net1 220.2e-3
rk3139 n798__i0__i14__net1 n799__i0__i14__net1 140.3e-3
rk3140 n799__i0__i14__net1 n800__i0__i14__net1 338.1e-3
rk3141 n800__i0__i14__net1 n801__i0__i14__net1 236.1e-3
rk3142 n801__i0__i14__net1 n802__i0__i14__net1 124.4e-3
rk3144 n791__i0__i14__net1 n792__i0__i14__net1 3.1
rk3145 n791__i0__i14__net1 n795__i0__i14__net1 3.1
rk3146 n791__i0__i14__net1 n798__i0__i14__net1 3.1
rk3147 n791__i0__i14__net1 n801__i0__i14__net1 3.1
rk3148 n6__i0__net2 n65__i0__net2 125e-3
rk3149 n8__i0__net2 n66__i0__net2 125e-3
rk3150 n12__reset n13__reset 576.1e-3
rk3152 n1101__vddio n1103__vddio 29.7e-3
rk3153 n1103__vddio n1104__vddio 330.8e-3
rk3154 n1104__vddio n1105__vddio 338.1e-3
rk3155 n1105__vddio n1106__vddio 42.07e-3
rk3156 n1106__vddio n1107__vddio 316.6e-3
rk3157 n1107__vddio n1108__vddio 357.3e-3
rk3158 n1108__vddio n1109__vddio 39.59e-3
rk3159 n1109__vddio n1110__vddio 319.1e-3
rk3160 n1110__vddio n1111__vddio 338.1e-3
rk3161 n1111__vddio n1112__vddio 51.97e-3
rk3162 n1112__vddio n1113__vddio 389.7e-3
rk3163 n1102__vddio n1103__vddio 3.1
rk3164 n1102__vddio n1106__vddio 3.1
rk3165 n1102__vddio n1109__vddio 3.1
rk3166 n1102__vddio n1112__vddio 3.1
rk3167 n756__vss n757__vss 54.44e-3
rk3168 n757__vss n758__vss 360.5e-3
rk3169 n758__vss n759__vss 294.3e-3
rk3170 n759__vss n760__vss 42.07e-3
rk3171 n760__vss n761__vss 360.5e-3
rk3172 n761__vss n762__vss 185e-3
rk3173 n762__vss n763__vss 262e-3
rk3174 n755__vss n756__vss 3.75
rk3175 n755__vss n759__vss 3.75
rk3176 n755__vss n762__vss 5.7692
rk3177 n14__pinin n15__pinin 19.278
rk3178 n15__pinin n17__pinin 515.4e-3
rk3179 n17__pinin n18__pinin 75.478
rk3180 n16__pinin n17__pinin 31
rk3181 n9__i0__net2 n77__i0__net2 125e-3
rk3182 n11__i0__net2 n78__i0__net2 125e-3
rk3184 n819__i0__i14__net1 n820__i0__i14__net1 12.37e-3
rk3185 n820__i0__i14__net1 n821__i0__i14__net1 360.5e-3
rk3186 n821__i0__i14__net1 n822__i0__i14__net1 223.4e-3
rk3187 n822__i0__i14__net1 n823__i0__i14__net1 114.8e-3
rk3188 n823__i0__i14__net1 n824__i0__i14__net1 360.5e-3
rk3189 n824__i0__i14__net1 n825__i0__i14__net1 239.3e-3
rk3190 n825__i0__i14__net1 n826__i0__i14__net1 118e-3
rk3192 n818__i0__i14__net1 n819__i0__i14__net1 5.7692
rk3193 n818__i0__i14__net1 n822__i0__i14__net1 3.75
rk3194 n818__i0__i14__net1 n825__i0__i14__net1 3.75
rk3196 n829__i0__i14__net1 n831__i0__i14__net1 207.4e-3
rk3197 n831__i0__i14__net1 n832__i0__i14__net1 153.1e-3
rk3198 n832__i0__i14__net1 n833__i0__i14__net1 338.1e-3
rk3199 n833__i0__i14__net1 n834__i0__i14__net1 223.4e-3
rk3200 n834__i0__i14__net1 n835__i0__i14__net1 137.1e-3
rk3201 n835__i0__i14__net1 n836__i0__i14__net1 357.3e-3
rk3202 n836__i0__i14__net1 n837__i0__i14__net1 220.2e-3
rk3203 n837__i0__i14__net1 n838__i0__i14__net1 140.3e-3
rk3204 n838__i0__i14__net1 n839__i0__i14__net1 338.1e-3
rk3205 n839__i0__i14__net1 n840__i0__i14__net1 236.1e-3
rk3206 n840__i0__i14__net1 n841__i0__i14__net1 124.4e-3
rk3208 n830__i0__i14__net1 n831__i0__i14__net1 3.1
rk3209 n830__i0__i14__net1 n834__i0__i14__net1 3.1
rk3210 n830__i0__i14__net1 n837__i0__i14__net1 3.1
rk3211 n830__i0__i14__net1 n840__i0__i14__net1 3.1
rk3212 n14__i0__net2 n81__i0__net2 125e-3
rk3213 n16__i0__net2 n82__i0__net2 125e-3
rk3214 n6__pinin n21__pinin 125e-3
rk3215 n769__vss n770__vss 54.44e-3
rk3216 n770__vss n771__vss 360.5e-3
rk3217 n771__vss n772__vss 294.3e-3
rk3218 n772__vss n773__vss 42.07e-3
rk3219 n773__vss n774__vss 360.5e-3
rk3220 n774__vss n775__vss 185e-3
rk3221 n775__vss n776__vss 262e-3
rk3222 n768__vss n769__vss 3.75
rk3223 n768__vss n772__vss 3.75
rk3224 n768__vss n775__vss 5.7692
rk3226 n1122__vddio n1124__vddio 29.7e-3
rk3227 n1124__vddio n1125__vddio 330.8e-3
rk3228 n1125__vddio n1126__vddio 338.1e-3
rk3229 n1126__vddio n1127__vddio 42.07e-3
rk3230 n1127__vddio n1128__vddio 316.6e-3
rk3231 n1128__vddio n1129__vddio 357.3e-3
rk3232 n1129__vddio n1130__vddio 39.59e-3
rk3233 n1130__vddio n1131__vddio 319.1e-3
rk3234 n1131__vddio n1132__vddio 338.1e-3
rk3235 n1132__vddio n1133__vddio 51.97e-3
rk3236 n1133__vddio n1134__vddio 389.7e-3
rk3237 n1123__vddio n1124__vddio 3.1
rk3238 n1123__vddio n1127__vddio 3.1
rk3239 n1123__vddio n1130__vddio 3.1
rk3240 n1123__vddio n1133__vddio 3.1
rk3244 n858__i0__i14__net1 n859__i0__i14__net1 12.37e-3
rk3245 n859__i0__i14__net1 n860__i0__i14__net1 360.5e-3
rk3246 n860__i0__i14__net1 n861__i0__i14__net1 223.4e-3
rk3247 n861__i0__i14__net1 n862__i0__i14__net1 114.8e-3
rk3248 n862__i0__i14__net1 n863__i0__i14__net1 360.5e-3
rk3249 n863__i0__i14__net1 n864__i0__i14__net1 239.3e-3
rk3250 n864__i0__i14__net1 n865__i0__i14__net1 118e-3
rk3252 n857__i0__i14__net1 n858__i0__i14__net1 5.7692
rk3253 n857__i0__i14__net1 n861__i0__i14__net1 3.75
rk3254 n857__i0__i14__net1 n864__i0__i14__net1 3.75
rk3256 n868__i0__i14__net1 n870__i0__i14__net1 209.2e-3
rk3257 n870__i0__i14__net1 n871__i0__i14__net1 154.9e-3
rk3258 n871__i0__i14__net1 n872__i0__i14__net1 341.7e-3
rk3259 n872__i0__i14__net1 n873__i0__i14__net1 225.2e-3
rk3260 n873__i0__i14__net1 n874__i0__i14__net1 138.9e-3
rk3261 n874__i0__i14__net1 n875__i0__i14__net1 360.9e-3
rk3262 n875__i0__i14__net1 n876__i0__i14__net1 222e-3
rk3263 n876__i0__i14__net1 n877__i0__i14__net1 142.1e-3
rk3264 n877__i0__i14__net1 n878__i0__i14__net1 341.7e-3
rk3265 n878__i0__i14__net1 n879__i0__i14__net1 237.9e-3
rk3266 n879__i0__i14__net1 n880__i0__i14__net1 126.2e-3
rk3268 n869__i0__i14__net1 n870__i0__i14__net1 3.1
rk3269 n869__i0__i14__net1 n873__i0__i14__net1 3.1
rk3270 n869__i0__i14__net1 n876__i0__i14__net1 3.1
rk3271 n869__i0__i14__net1 n879__i0__i14__net1 3.1
rk3272 n22__i0__net2 n97__i0__net2 125e-3
rk3273 n24__i0__net2 n98__i0__net2 125e-3
rk3274 pinout n2__pinout 31.2555
rk3275 n2__pinout n3__pinout 220.1e-3
rk3276 n3__pinout n4__pinout 75.291
rk3277 n2__pinout n5__pinout 75.2214
rk3278 n3__pinout n6__pinout 31.3206
rk3279 n781__vss n782__vss 75.1438
rk3280 n782__vss n783__vss 72.37e-3
rk3281 n783__vss n784__vss 217.4e-3
rk3282 n784__vss n785__vss 37.38e-3
rk3283 n785__vss n786__vss 553.7e-3
rk3284 n782__vss n787__vss 75.1234
rk3285 n783__vss n788__vss 75.1091
rk3286 n785__vss n789__vss 19.1152
rk3287 n786__vss n790__vss 550.2e-3
rk3288 n790__vss n791__vss 604.5e-3
rk3289 n791__vss n792__vss 320.6e-3
rk3290 n792__vss n793__vss 258.8e-3
rk3291 n793__vss n794__vss 46.49e-3
rk3292 n794__vss n795__vss 596.9e-3
rk3293 n795__vss n796__vss 160.5e-3
rk3294 n796__vss n797__vss 381.1e-3
rk3295 n797__vss n798__vss 595.1e-3
rk3296 n798__vss n799__vss 315.4e-3
rk3297 n799__vss n800__vss 67.37e-3
rk3298 n800__vss n801__vss 187.3e-3
rk3299 n801__vss n802__vss 45.48e-3
rk3300 n802__vss n803__vss 595.1e-3
rk3301 n803__vss n623__vss 532.6e-3
rk3302 n623__vss n804__vss 605.6e-3
rk3303 n804__vss n805__vss 319.8e-3
rk3304 n805__vss n806__vss 275e-3
rk3305 n806__vss n417__vss 2.432e-3
rk3306 n417__vss n807__vss 75.6641
rk3307 n786__vss n808__vss 75.419
rk3308 n790__vss n809__vss 75.4056
rk3309 n792__vss n810__vss 75.401
rk3310 n794__vss n811__vss 19.118
rk3311 n795__vss n812__vss 75.4177
rk3312 n797__vss n813__vss 75.4064
rk3313 n799__vss n814__vss 75.4019
rk3314 n802__vss n815__vss 19.1189
rk3315 n803__vss n816__vss 75.4177
rk3316 n623__vss n817__vss 75.4177
rk3317 n805__vss n818__vss 75.401
rk3318 n573__vss n782__vss 7.75
rk3319 n573__vss n784__vss 31
rk3320 n573__vss n786__vss 3.1
rk3321 n573__vss n791__vss 5.1667
rk3322 n573__vss n793__vss 31
rk3323 n573__vss n795__vss 3.1
rk3324 n618__vss n796__vss 25e-3
rk3325 n573__vss n798__vss 5.1667
rk3326 n620__vss n800__vss 25e-3
rk3327 n573__vss n801__vss 31
rk3328 n573__vss n803__vss 3.1
rk3329 n573__vss n804__vss 5.1667
rk3330 n573__vss n806__vss 20.6667
rk3331 n5__vdd n7__vdd 31.2084
rk3332 n7__vdd n8__vdd 137.2e-3
rk3333 n8__vdd n9__vdd 205e-3
rk3334 n9__vdd n10__vdd 591.1e-3
rk3335 n7__vdd n11__vdd 31.3352
rk3336 n8__vdd n12__vdd 31.1784
rk3337 n10__vdd n13__vdd 31.3835
rk3338 n10__vdd n14__vdd 563.4e-3
rk3339 n14__vdd n15__vdd 31.3685
rk3340 n14__vdd n16__vdd 619e-3
rk3341 n16__vdd n17__vdd 328.3e-3
rk3342 n17__vdd n18__vdd 31.4737
rk3343 n17__vdd n19__vdd 265.2e-3
rk3344 n19__vdd n20__vdd 667.9e-3
rk3345 n20__vdd n21__vdd 31.3835
rk3346 n20__vdd n22__vdd 563.4e-3
rk3347 n22__vdd n23__vdd 31.3685
rk3348 n22__vdd n24__vdd 619e-3
rk3349 n24__vdd n25__vdd 328.3e-3
rk3350 n25__vdd n26__vdd 31.4737
rk3351 n25__vdd n27__vdd 265.2e-3
rk3352 n27__vdd n28__vdd 667.9e-3
rk3353 n28__vdd n29__vdd 31.3835
rk3354 n28__vdd n30__vdd 563.4e-3
rk3355 n30__vdd n31__vdd 31.3685
rk3356 n30__vdd n32__vdd 619e-3
rk3357 n32__vdd n2__vdd 134.9e-3
rk3358 n2__vdd n33__vdd 185.3e-3
rk3359 n33__vdd n34__vdd 31.4737
rk3360 n33__vdd n35__vdd 293e-3
rk3361 n35__vdd n36__vdd 45.29e-3
rk3362 n36__vdd n37__vdd 31.2931
rk3363 n36__vdd n38__vdd 2.2466
rk3364 n38__vdd n39__vdd 31.2931
rk3365 n38__vdd n41__vdd 45.29e-3
rk3366 n41__vdd n42__vdd 298e-3
rk3367 n42__vdd n43__vdd 31.3685
rk3368 n42__vdd vdd 515.4e-3
rk3370 vdd n45__vdd 75.37e-3
rk3371 n45__vdd n46__vdd 31.3685
rk3372 n45__vdd n47__vdd 611.3e-3
rk3373 n47__vdd n48__vdd 31.2931
rk3374 n47__vdd n49__vdd 45.29e-3
rk3375 n49__vdd n50__vdd 250e-3
rk3376 n50__vdd n51__vdd 31.2931
rk3377 n50__vdd n52__vdd 45.29e-3
rk3378 n52__vdd n53__vdd 298e-3
rk3379 n53__vdd n54__vdd 31.3685
rk3380 n53__vdd n55__vdd 515.4e-3
rk3381 n55__vdd n56__vdd 75.62e-3
rk3382 n56__vdd n57__vdd 31.3685
rk3383 n56__vdd n58__vdd 611.3e-3
rk3384 n58__vdd n59__vdd 31.2931
rk3385 n58__vdd n60__vdd 45.29e-3
rk3386 n60__vdd n61__vdd 272.7e-3
rk3387 n61__vdd n62__vdd 15.9388
rk3388 n61__vdd n63__vdd 242.4e-3
rk3389 n63__vdd n64__vdd 31.7463
rk3390 n6__vdd n7__vdd 9.375
rk3391 n6__vdd n9__vdd 37.5
rk3392 n6__vdd n10__vdd 3.75
rk3393 n6__vdd n16__vdd 6.25
rk3394 n6__vdd n19__vdd 37.5
rk3395 n6__vdd n20__vdd 3.75
rk3396 n6__vdd n24__vdd 6.25
rk3397 n6__vdd n27__vdd 37.5
rk3398 n6__vdd n28__vdd 3.75
rk3399 n6__vdd n32__vdd 6.25
rk3400 n6__vdd n35__vdd 25
rk3401 n40__vdd n41__vdd 25
rk3402 n40__vdd vdd 4.1667
rk3403 n40__vdd n49__vdd 25
rk3404 n40__vdd n52__vdd 25
rk3405 n40__vdd n55__vdd 4.1667
rk3406 n40__vdd n60__vdd 25
rk3407 n40__vdd n63__vdd 7.5
rk3408 n820__vss n821__vss 54.44e-3
rk3409 n821__vss n822__vss 360.5e-3
rk3410 n822__vss n823__vss 294.3e-3
rk3411 n823__vss n824__vss 42.07e-3
rk3412 n824__vss n825__vss 360.5e-3
rk3413 n825__vss n826__vss 185e-3
rk3414 n826__vss n827__vss 262e-3
rk3415 n819__vss n820__vss 3.75
rk3416 n819__vss n823__vss 3.75
rk3417 n819__vss n826__vss 5.7692
rk3419 n1143__vddio n1145__vddio 29.7e-3
rk3420 n1145__vddio n1146__vddio 330.8e-3
rk3421 n1146__vddio n1147__vddio 338.1e-3
rk3422 n1147__vddio n1148__vddio 42.07e-3
rk3423 n1148__vddio n1149__vddio 316.6e-3
rk3424 n1149__vddio n1150__vddio 357.3e-3
rk3425 n1150__vddio n1151__vddio 39.59e-3
rk3426 n1151__vddio n1152__vddio 319.1e-3
rk3427 n1152__vddio n1153__vddio 338.1e-3
rk3428 n1153__vddio n1154__vddio 51.97e-3
rk3429 n1154__vddio n1155__vddio 389.7e-3
rk3430 n1144__vddio n1145__vddio 3.1
rk3431 n1144__vddio n1148__vddio 3.1
rk3432 n1144__vddio n1151__vddio 3.1
rk3433 n1144__vddio n1154__vddio 3.1
rk3434 n26__i0__net2 n109__i0__net2 125e-3
rk3435 n28__i0__net2 n110__i0__net2 125e-3
rk3437 n897__i0__i14__net1 n898__i0__i14__net1 12.37e-3
rk3438 n898__i0__i14__net1 n899__i0__i14__net1 360.5e-3
rk3439 n899__i0__i14__net1 n900__i0__i14__net1 223.4e-3
rk3440 n900__i0__i14__net1 n901__i0__i14__net1 114.8e-3
rk3441 n901__i0__i14__net1 n902__i0__i14__net1 360.5e-3
rk3442 n902__i0__i14__net1 n903__i0__i14__net1 239.3e-3
rk3443 n903__i0__i14__net1 n904__i0__i14__net1 118e-3
rk3445 n896__i0__i14__net1 n897__i0__i14__net1 5.7692
rk3446 n896__i0__i14__net1 n900__i0__i14__net1 3.75
rk3447 n896__i0__i14__net1 n903__i0__i14__net1 3.75
rk3449 n907__i0__i14__net1 n909__i0__i14__net1 209.2e-3
rk3450 n909__i0__i14__net1 n910__i0__i14__net1 154.9e-3
rk3451 n910__i0__i14__net1 n911__i0__i14__net1 341.7e-3
rk3452 n911__i0__i14__net1 n912__i0__i14__net1 225.2e-3
rk3453 n912__i0__i14__net1 n913__i0__i14__net1 138.9e-3
rk3454 n913__i0__i14__net1 n914__i0__i14__net1 360.9e-3
rk3455 n914__i0__i14__net1 n915__i0__i14__net1 222e-3
rk3456 n915__i0__i14__net1 n916__i0__i14__net1 142.1e-3
rk3457 n916__i0__i14__net1 n917__i0__i14__net1 341.7e-3
rk3458 n917__i0__i14__net1 n918__i0__i14__net1 237.9e-3
rk3459 n918__i0__i14__net1 n919__i0__i14__net1 126.2e-3
rk3461 n908__i0__i14__net1 n909__i0__i14__net1 3.1
rk3462 n908__i0__i14__net1 n912__i0__i14__net1 3.1
rk3463 n908__i0__i14__net1 n915__i0__i14__net1 3.1
rk3464 n908__i0__i14__net1 n918__i0__i14__net1 3.1
rk3465 n30__i0__net2 n113__i0__net2 125e-3
rk3466 n32__i0__net2 n114__i0__net2 125e-3
rk3468 n1164__vddio n1166__vddio 29.7e-3
rk3469 n1166__vddio n1167__vddio 330.8e-3
rk3470 n1167__vddio n1168__vddio 338.1e-3
rk3471 n1168__vddio n1169__vddio 42.07e-3
rk3472 n1169__vddio n1170__vddio 316.6e-3
rk3473 n1170__vddio n1171__vddio 357.3e-3
rk3474 n1171__vddio n1172__vddio 39.59e-3
rk3475 n1172__vddio n1173__vddio 319.1e-3
rk3476 n1173__vddio n1174__vddio 338.1e-3
rk3477 n1174__vddio n1175__vddio 51.97e-3
rk3478 n1175__vddio n1176__vddio 389.7e-3
rk3479 n1165__vddio n1166__vddio 3.1
rk3480 n1165__vddio n1169__vddio 3.1
rk3481 n1165__vddio n1172__vddio 3.1
rk3482 n1165__vddio n1175__vddio 3.1
rk3483 n833__vss n834__vss 54.44e-3
rk3484 n834__vss n835__vss 360.5e-3
rk3485 n835__vss n836__vss 294.3e-3
rk3486 n836__vss n837__vss 42.07e-3
rk3487 n837__vss n838__vss 360.5e-3
rk3488 n838__vss n839__vss 185e-3
rk3489 n839__vss n840__vss 262e-3
rk3490 n832__vss n833__vss 3.75
rk3491 n832__vss n836__vss 3.75
rk3492 n832__vss n839__vss 5.7692
rk3493 n34__i0__net2 n125__i0__net2 125e-3
rk3494 n36__i0__net2 n126__i0__net2 125e-3
rk3496 n936__i0__i14__net1 n937__i0__i14__net1 12.37e-3
rk3497 n937__i0__i14__net1 n938__i0__i14__net1 360.5e-3
rk3498 n938__i0__i14__net1 n939__i0__i14__net1 223.4e-3
rk3499 n939__i0__i14__net1 n940__i0__i14__net1 114.8e-3
rk3500 n940__i0__i14__net1 n941__i0__i14__net1 360.5e-3
rk3501 n941__i0__i14__net1 n942__i0__i14__net1 239.3e-3
rk3502 n942__i0__i14__net1 n943__i0__i14__net1 118e-3
rk3504 n935__i0__i14__net1 n936__i0__i14__net1 5.7692
rk3505 n935__i0__i14__net1 n939__i0__i14__net1 3.75
rk3506 n935__i0__i14__net1 n942__i0__i14__net1 3.75
rk3508 n946__i0__i14__net1 n948__i0__i14__net1 207.4e-3
rk3509 n948__i0__i14__net1 n949__i0__i14__net1 153.1e-3
rk3510 n949__i0__i14__net1 n950__i0__i14__net1 338.1e-3
rk3511 n950__i0__i14__net1 n951__i0__i14__net1 223.4e-3
rk3512 n951__i0__i14__net1 n952__i0__i14__net1 137.1e-3
rk3513 n952__i0__i14__net1 n953__i0__i14__net1 357.3e-3
rk3514 n953__i0__i14__net1 n954__i0__i14__net1 220.2e-3
rk3515 n954__i0__i14__net1 n955__i0__i14__net1 140.3e-3
rk3516 n955__i0__i14__net1 n956__i0__i14__net1 338.1e-3
rk3517 n956__i0__i14__net1 n957__i0__i14__net1 236.1e-3
rk3518 n957__i0__i14__net1 n958__i0__i14__net1 124.4e-3
rk3520 n947__i0__i14__net1 n948__i0__i14__net1 3.1
rk3521 n947__i0__i14__net1 n951__i0__i14__net1 3.1
rk3522 n947__i0__i14__net1 n954__i0__i14__net1 3.1
rk3523 n947__i0__i14__net1 n957__i0__i14__net1 3.1
rk3524 n38__i0__net2 n129__i0__net2 125e-3
rk3525 n40__i0__net2 n130__i0__net2 125e-3
rk3527 n1185__vddio n1187__vddio 29.7e-3
rk3528 n1187__vddio n1188__vddio 330.8e-3
rk3529 n1188__vddio n1189__vddio 338.1e-3
rk3530 n1189__vddio n1190__vddio 42.07e-3
rk3531 n1190__vddio n1191__vddio 316.6e-3
rk3532 n1191__vddio n1192__vddio 357.3e-3
rk3533 n1192__vddio n1193__vddio 39.59e-3
rk3534 n1193__vddio n1194__vddio 319.1e-3
rk3535 n1194__vddio n1195__vddio 338.1e-3
rk3536 n1195__vddio n1196__vddio 51.97e-3
rk3537 n1196__vddio n1197__vddio 389.7e-3
rk3538 n1186__vddio n1187__vddio 3.1
rk3539 n1186__vddio n1190__vddio 3.1
rk3540 n1186__vddio n1193__vddio 3.1
rk3541 n1186__vddio n1196__vddio 3.1
rk3542 n846__vss n847__vss 54.44e-3
rk3543 n847__vss n848__vss 360.5e-3
rk3544 n848__vss n849__vss 294.3e-3
rk3545 n849__vss n850__vss 42.07e-3
rk3546 n850__vss n851__vss 360.5e-3
rk3547 n851__vss n852__vss 185e-3
rk3548 n852__vss n853__vss 262e-3
rk3549 n845__vss n846__vss 3.75
rk3550 n845__vss n849__vss 3.75
rk3551 n845__vss n852__vss 5.7692
rk3552 n42__i0__net2 n141__i0__net2 125e-3
rk3553 n44__i0__net2 n142__i0__net2 125e-3
rk3555 n975__i0__i14__net1 n976__i0__i14__net1 12.37e-3
rk3556 n976__i0__i14__net1 n977__i0__i14__net1 360.5e-3
rk3557 n977__i0__i14__net1 n978__i0__i14__net1 223.4e-3
rk3558 n978__i0__i14__net1 n979__i0__i14__net1 114.8e-3
rk3559 n979__i0__i14__net1 n980__i0__i14__net1 360.5e-3
rk3560 n980__i0__i14__net1 n981__i0__i14__net1 239.3e-3
rk3561 n981__i0__i14__net1 n982__i0__i14__net1 118e-3
rk3563 n974__i0__i14__net1 n975__i0__i14__net1 5.7692
rk3564 n974__i0__i14__net1 n978__i0__i14__net1 3.75
rk3565 n974__i0__i14__net1 n981__i0__i14__net1 3.75
rk3567 n985__i0__i14__net1 n987__i0__i14__net1 207.4e-3
rk3568 n987__i0__i14__net1 n988__i0__i14__net1 153.1e-3
rk3569 n988__i0__i14__net1 n989__i0__i14__net1 338.1e-3
rk3570 n989__i0__i14__net1 n990__i0__i14__net1 223.4e-3
rk3571 n990__i0__i14__net1 n991__i0__i14__net1 137.1e-3
rk3572 n991__i0__i14__net1 n992__i0__i14__net1 357.3e-3
rk3573 n992__i0__i14__net1 n993__i0__i14__net1 220.2e-3
rk3574 n993__i0__i14__net1 n994__i0__i14__net1 140.3e-3
rk3575 n994__i0__i14__net1 n995__i0__i14__net1 338.1e-3
rk3576 n995__i0__i14__net1 n996__i0__i14__net1 236.1e-3
rk3577 n996__i0__i14__net1 n997__i0__i14__net1 124.4e-3
rk3579 n986__i0__i14__net1 n987__i0__i14__net1 3.1
rk3580 n986__i0__i14__net1 n990__i0__i14__net1 3.1
rk3581 n986__i0__i14__net1 n993__i0__i14__net1 3.1
rk3582 n986__i0__i14__net1 n996__i0__i14__net1 3.1
rk3583 n46__i0__net2 n145__i0__net2 125e-3
rk3584 n48__i0__net2 n146__i0__net2 125e-3
rk3585 n859__vss n860__vss 54.44e-3
rk3586 n860__vss n861__vss 360.5e-3
rk3587 n861__vss n862__vss 294.3e-3
rk3588 n862__vss n863__vss 42.07e-3
rk3589 n863__vss n864__vss 360.5e-3
rk3590 n864__vss n865__vss 185e-3
rk3591 n865__vss n866__vss 262e-3
rk3592 n858__vss n859__vss 3.75
rk3593 n858__vss n862__vss 3.75
rk3594 n858__vss n865__vss 5.7692
rk3596 n1206__vddio n1208__vddio 29.7e-3
rk3597 n1208__vddio n1209__vddio 330.8e-3
rk3598 n1209__vddio n1210__vddio 338.1e-3
rk3599 n1210__vddio n1211__vddio 42.07e-3
rk3600 n1211__vddio n1212__vddio 316.6e-3
rk3601 n1212__vddio n1213__vddio 357.3e-3
rk3602 n1213__vddio n1214__vddio 39.59e-3
rk3603 n1214__vddio n1215__vddio 319.1e-3
rk3604 n1215__vddio n1216__vddio 338.1e-3
rk3605 n1216__vddio n1217__vddio 51.97e-3
rk3606 n1217__vddio n1218__vddio 389.7e-3
rk3607 n1207__vddio n1208__vddio 3.1
rk3608 n1207__vddio n1211__vddio 3.1
rk3609 n1207__vddio n1214__vddio 3.1
rk3610 n1207__vddio n1217__vddio 3.1
rk3611 n50__i0__net2 n157__i0__net2 125e-3
rk3612 n52__i0__net2 n158__i0__net2 125e-3
rk3614 n1013__i0__i14__net1 n1015__i0__i14__net1 207.4e-3
rk3615 n1015__i0__i14__net1 n1016__i0__i14__net1 153.1e-3
rk3616 n1016__i0__i14__net1 n1017__i0__i14__net1 338.1e-3
rk3617 n1017__i0__i14__net1 n1018__i0__i14__net1 223.4e-3
rk3618 n1018__i0__i14__net1 n1019__i0__i14__net1 137.1e-3
rk3619 n1019__i0__i14__net1 n1020__i0__i14__net1 357.3e-3
rk3620 n1020__i0__i14__net1 n1021__i0__i14__net1 220.2e-3
rk3621 n1021__i0__i14__net1 n1022__i0__i14__net1 140.3e-3
rk3622 n1022__i0__i14__net1 n1023__i0__i14__net1 338.1e-3
rk3623 n1023__i0__i14__net1 n1024__i0__i14__net1 236.1e-3
rk3624 n1024__i0__i14__net1 n1025__i0__i14__net1 124.4e-3
rk3626 n1014__i0__i14__net1 n1015__i0__i14__net1 3.1
rk3627 n1014__i0__i14__net1 n1018__i0__i14__net1 3.1
rk3628 n1014__i0__i14__net1 n1021__i0__i14__net1 3.1
rk3629 n1014__i0__i14__net1 n1024__i0__i14__net1 3.1
rk3631 n1029__i0__i14__net1 n1030__i0__i14__net1 12.37e-3
rk3632 n1030__i0__i14__net1 n1031__i0__i14__net1 360.5e-3
rk3633 n1031__i0__i14__net1 n1032__i0__i14__net1 223.4e-3
rk3634 n1032__i0__i14__net1 n1033__i0__i14__net1 114.8e-3
rk3635 n1033__i0__i14__net1 n1034__i0__i14__net1 360.5e-3
rk3636 n1034__i0__i14__net1 n1035__i0__i14__net1 239.3e-3
rk3637 n1035__i0__i14__net1 n1036__i0__i14__net1 118e-3
rk3639 n1028__i0__i14__net1 n1029__i0__i14__net1 5.7692
rk3640 n1028__i0__i14__net1 n1032__i0__i14__net1 3.75
rk3641 n1028__i0__i14__net1 n1035__i0__i14__net1 3.75
rk3645 n1226__vddio n1242__vddio 29.7e-3
rk3646 n1242__vddio n1229__vddio 330.8e-3
rk3647 n1229__vddio n1230__vddio 338.1e-3
rk3648 n1230__vddio n1243__vddio 42.07e-3
rk3649 n1243__vddio n1233__vddio 316.6e-3
rk3650 n1233__vddio n1234__vddio 357.3e-3
rk3651 n1234__vddio n1244__vddio 39.59e-3
rk3652 n1244__vddio n1237__vddio 319.1e-3
rk3653 n1237__vddio n1238__vddio 338.1e-3
rk3654 n1238__vddio n1245__vddio 51.97e-3
rk3655 n1245__vddio n1246__vddio 389.7e-3
rk3656 n1241__vddio n1242__vddio 3.1
rk3657 n1241__vddio n1243__vddio 3.1
rk3658 n1241__vddio n1244__vddio 3.1
rk3659 n1241__vddio n1245__vddio 3.1
rk3660 n880__vss n878__vss 54.44e-3
rk3661 n878__vss n875__vss 360.5e-3
rk3662 n875__vss n881__vss 294.3e-3
rk3663 n881__vss n874__vss 42.07e-3
rk3664 n874__vss n871__vss 360.5e-3
rk3665 n871__vss n882__vss 185e-3
rk3666 n882__vss n883__vss 262e-3
rk3667 n879__vss n880__vss 3.75
rk3668 n879__vss n881__vss 3.75
rk3669 n879__vss n882__vss 5.7692
rk3670 n58__i0__net2 n165__i0__net2 125e-3
rk3671 n60__i0__net2 n166__i0__net2 125e-3
rk3673 n1052__i0__i14__net1 n1054__i0__i14__net1 207.4e-3
rk3674 n1054__i0__i14__net1 n1055__i0__i14__net1 153.1e-3
rk3675 n1055__i0__i14__net1 n1056__i0__i14__net1 338.1e-3
rk3676 n1056__i0__i14__net1 n1057__i0__i14__net1 223.4e-3
rk3677 n1057__i0__i14__net1 n1058__i0__i14__net1 137.1e-3
rk3678 n1058__i0__i14__net1 n1059__i0__i14__net1 357.3e-3
rk3679 n1059__i0__i14__net1 n1060__i0__i14__net1 220.2e-3
rk3680 n1060__i0__i14__net1 n1061__i0__i14__net1 140.3e-3
rk3681 n1061__i0__i14__net1 n1062__i0__i14__net1 338.1e-3
rk3682 n1062__i0__i14__net1 n1063__i0__i14__net1 236.1e-3
rk3683 n1063__i0__i14__net1 n1064__i0__i14__net1 124.4e-3
rk3685 n1053__i0__i14__net1 n1054__i0__i14__net1 3.1
rk3686 n1053__i0__i14__net1 n1057__i0__i14__net1 3.1
rk3687 n1053__i0__i14__net1 n1060__i0__i14__net1 3.1
rk3688 n1053__i0__i14__net1 n1063__i0__i14__net1 3.1
rk3690 n1068__i0__i14__net1 n1069__i0__i14__net1 12.37e-3
rk3691 n1069__i0__i14__net1 n1070__i0__i14__net1 360.5e-3
rk3692 n1070__i0__i14__net1 n1071__i0__i14__net1 223.4e-3
rk3693 n1071__i0__i14__net1 n1072__i0__i14__net1 114.8e-3
rk3694 n1072__i0__i14__net1 n1073__i0__i14__net1 360.5e-3
rk3695 n1073__i0__i14__net1 n1074__i0__i14__net1 239.3e-3
rk3696 n1074__i0__i14__net1 n1075__i0__i14__net1 118e-3
rk3698 n1067__i0__i14__net1 n1068__i0__i14__net1 5.7692
rk3699 n1067__i0__i14__net1 n1071__i0__i14__net1 3.75
rk3700 n1067__i0__i14__net1 n1074__i0__i14__net1 3.75
rk3701 n70__i0__net2 n167__i0__net2 125e-3
rk3702 n72__i0__net2 n168__i0__net2 125e-3
rk3704 n1248__vddio n1250__vddio 29.7e-3
rk3705 n1250__vddio n1251__vddio 330.8e-3
rk3706 n1251__vddio n1252__vddio 338.1e-3
rk3707 n1252__vddio n1253__vddio 42.07e-3
rk3708 n1253__vddio n1254__vddio 316.6e-3
rk3709 n1254__vddio n1255__vddio 357.3e-3
rk3710 n1255__vddio n1256__vddio 39.59e-3
rk3711 n1256__vddio n1257__vddio 319.1e-3
rk3712 n1257__vddio n1258__vddio 338.1e-3
rk3713 n1258__vddio n1259__vddio 51.97e-3
rk3714 n1259__vddio n1260__vddio 389.7e-3
rk3715 n1249__vddio n1250__vddio 3.1
rk3716 n1249__vddio n1253__vddio 3.1
rk3717 n1249__vddio n1256__vddio 3.1
rk3718 n1249__vddio n1259__vddio 3.1
rk3719 n885__vss n886__vss 54.44e-3
rk3720 n886__vss n887__vss 360.5e-3
rk3721 n887__vss n888__vss 294.3e-3
rk3722 n888__vss n889__vss 42.07e-3
rk3723 n889__vss n890__vss 360.5e-3
rk3724 n890__vss n891__vss 185e-3
rk3725 n891__vss n892__vss 262e-3
rk3726 n884__vss n885__vss 3.75
rk3727 n884__vss n888__vss 3.75
rk3728 n884__vss n891__vss 5.7692
rk3729 n74__i0__net2 n173__i0__net2 125e-3
rk3730 n76__i0__net2 n174__i0__net2 125e-3
rk3732 n1092__i0__i14__net1 n1093__i0__i14__net1 12.37e-3
rk3733 n1093__i0__i14__net1 n1094__i0__i14__net1 360.5e-3
rk3734 n1094__i0__i14__net1 n1095__i0__i14__net1 223.4e-3
rk3735 n1095__i0__i14__net1 n1096__i0__i14__net1 114.8e-3
rk3736 n1096__i0__i14__net1 n1097__i0__i14__net1 360.5e-3
rk3737 n1097__i0__i14__net1 n1098__i0__i14__net1 239.3e-3
rk3738 n1098__i0__i14__net1 n1099__i0__i14__net1 118e-3
rk3740 n1091__i0__i14__net1 n1092__i0__i14__net1 5.7692
rk3741 n1091__i0__i14__net1 n1095__i0__i14__net1 3.75
rk3742 n1091__i0__i14__net1 n1098__i0__i14__net1 3.75
rk3744 n1102__i0__i14__net1 n1104__i0__i14__net1 207.4e-3
rk3745 n1104__i0__i14__net1 n1105__i0__i14__net1 153.1e-3
rk3746 n1105__i0__i14__net1 n1106__i0__i14__net1 338.1e-3
rk3747 n1106__i0__i14__net1 n1107__i0__i14__net1 223.4e-3
rk3748 n1107__i0__i14__net1 n1108__i0__i14__net1 137.1e-3
rk3749 n1108__i0__i14__net1 n1109__i0__i14__net1 357.3e-3
rk3750 n1109__i0__i14__net1 n1110__i0__i14__net1 220.2e-3
rk3751 n1110__i0__i14__net1 n1111__i0__i14__net1 140.3e-3
rk3752 n1111__i0__i14__net1 n1112__i0__i14__net1 338.1e-3
rk3753 n1112__i0__i14__net1 n1113__i0__i14__net1 236.1e-3
rk3754 n1113__i0__i14__net1 n1114__i0__i14__net1 124.4e-3
rk3756 n1103__i0__i14__net1 n1104__i0__i14__net1 3.1
rk3757 n1103__i0__i14__net1 n1107__i0__i14__net1 3.1
rk3758 n1103__i0__i14__net1 n1110__i0__i14__net1 3.1
rk3759 n1103__i0__i14__net1 n1113__i0__i14__net1 3.1
rk3760 n86__i0__net2 n181__i0__net2 125e-3
rk3761 n88__i0__net2 n182__i0__net2 125e-3
rk3762 n898__vss n899__vss 54.44e-3
rk3763 n899__vss n900__vss 360.5e-3
rk3764 n900__vss n901__vss 294.3e-3
rk3765 n901__vss n902__vss 42.07e-3
rk3766 n902__vss n903__vss 360.5e-3
rk3767 n903__vss n904__vss 185e-3
rk3768 n904__vss n905__vss 262e-3
rk3769 n897__vss n898__vss 3.75
rk3770 n897__vss n901__vss 3.75
rk3771 n897__vss n904__vss 5.7692
rk3773 n1269__vddio n1271__vddio 29.7e-3
rk3774 n1271__vddio n1272__vddio 330.8e-3
rk3775 n1272__vddio n1273__vddio 338.1e-3
rk3776 n1273__vddio n1274__vddio 42.07e-3
rk3777 n1274__vddio n1275__vddio 316.6e-3
rk3778 n1275__vddio n1276__vddio 357.3e-3
rk3779 n1276__vddio n1277__vddio 39.59e-3
rk3780 n1277__vddio n1278__vddio 319.1e-3
rk3781 n1278__vddio n1279__vddio 338.1e-3
rk3782 n1279__vddio n1280__vddio 51.97e-3
rk3783 n1280__vddio n1281__vddio 389.7e-3
rk3784 n1270__vddio n1271__vddio 3.1
rk3785 n1270__vddio n1274__vddio 3.1
rk3786 n1270__vddio n1277__vddio 3.1
rk3787 n1270__vddio n1280__vddio 3.1
rk3788 n94__i0__net2 n185__i0__net2 125e-3
rk3789 n96__i0__net2 n186__i0__net2 125e-3
rk3791 n1131__i0__i14__net1 n1132__i0__i14__net1 12.37e-3
rk3792 n1132__i0__i14__net1 n1133__i0__i14__net1 360.5e-3
rk3793 n1133__i0__i14__net1 n1134__i0__i14__net1 223.4e-3
rk3794 n1134__i0__i14__net1 n1135__i0__i14__net1 114.8e-3
rk3795 n1135__i0__i14__net1 n1136__i0__i14__net1 360.5e-3
rk3796 n1136__i0__i14__net1 n1137__i0__i14__net1 239.3e-3
rk3797 n1137__i0__i14__net1 n1138__i0__i14__net1 118e-3
rk3799 n1130__i0__i14__net1 n1131__i0__i14__net1 5.7692
rk3800 n1130__i0__i14__net1 n1134__i0__i14__net1 3.75
rk3801 n1130__i0__i14__net1 n1137__i0__i14__net1 3.75
rk3803 n1141__i0__i14__net1 n1143__i0__i14__net1 207.4e-3
rk3804 n1143__i0__i14__net1 n1144__i0__i14__net1 153.1e-3
rk3805 n1144__i0__i14__net1 n1145__i0__i14__net1 338.1e-3
rk3806 n1145__i0__i14__net1 n1146__i0__i14__net1 223.4e-3
rk3807 n1146__i0__i14__net1 n1147__i0__i14__net1 137.1e-3
rk3808 n1147__i0__i14__net1 n1148__i0__i14__net1 357.3e-3
rk3809 n1148__i0__i14__net1 n1149__i0__i14__net1 220.2e-3
rk3810 n1149__i0__i14__net1 n1150__i0__i14__net1 140.3e-3
rk3811 n1150__i0__i14__net1 n1151__i0__i14__net1 338.1e-3
rk3812 n1151__i0__i14__net1 n1152__i0__i14__net1 236.1e-3
rk3813 n1152__i0__i14__net1 n1153__i0__i14__net1 124.4e-3
rk3815 n1142__i0__i14__net1 n1143__i0__i14__net1 3.1
rk3816 n1142__i0__i14__net1 n1146__i0__i14__net1 3.1
rk3817 n1142__i0__i14__net1 n1149__i0__i14__net1 3.1
rk3818 n1142__i0__i14__net1 n1152__i0__i14__net1 3.1
rk3819 n102__i0__net2 n189__i0__net2 125e-3
rk3820 n104__i0__net2 n190__i0__net2 125e-3
rk3821 n911__vss n912__vss 54.44e-3
rk3822 n912__vss n913__vss 360.5e-3
rk3823 n913__vss n914__vss 294.3e-3
rk3824 n914__vss n915__vss 42.07e-3
rk3825 n915__vss n916__vss 360.5e-3
rk3826 n916__vss n917__vss 185e-3
rk3827 n917__vss n918__vss 262e-3
rk3828 n910__vss n911__vss 3.75
rk3829 n910__vss n914__vss 3.75
rk3830 n910__vss n917__vss 5.7692
rk3832 n1290__vddio n1292__vddio 29.7e-3
rk3833 n1292__vddio n1293__vddio 330.8e-3
rk3834 n1293__vddio n1294__vddio 338.1e-3
rk3835 n1294__vddio n1295__vddio 42.07e-3
rk3836 n1295__vddio n1296__vddio 316.6e-3
rk3837 n1296__vddio n1297__vddio 357.3e-3
rk3838 n1297__vddio n1298__vddio 39.59e-3
rk3839 n1298__vddio n1299__vddio 319.1e-3
rk3840 n1299__vddio n1300__vddio 338.1e-3
rk3841 n1300__vddio n1301__vddio 51.97e-3
rk3842 n1301__vddio n1302__vddio 389.7e-3
rk3843 n1291__vddio n1292__vddio 3.1
rk3844 n1291__vddio n1295__vddio 3.1
rk3845 n1291__vddio n1298__vddio 3.1
rk3846 n1291__vddio n1301__vddio 3.1
rk3847 n106__i0__net2 n193__i0__net2 125e-3
rk3848 n108__i0__net2 n194__i0__net2 125e-3
rk3850 n1169__i0__i14__net1 n1171__i0__i14__net1 207.4e-3
rk3851 n1171__i0__i14__net1 n1172__i0__i14__net1 153.1e-3
rk3852 n1172__i0__i14__net1 n1173__i0__i14__net1 338.1e-3
rk3853 n1173__i0__i14__net1 n1174__i0__i14__net1 223.4e-3
rk3854 n1174__i0__i14__net1 n1175__i0__i14__net1 137.1e-3
rk3855 n1175__i0__i14__net1 n1176__i0__i14__net1 357.3e-3
rk3856 n1176__i0__i14__net1 n1177__i0__i14__net1 220.2e-3
rk3857 n1177__i0__i14__net1 n1178__i0__i14__net1 140.3e-3
rk3858 n1178__i0__i14__net1 n1179__i0__i14__net1 338.1e-3
rk3859 n1179__i0__i14__net1 n1180__i0__i14__net1 236.1e-3
rk3860 n1180__i0__i14__net1 n1181__i0__i14__net1 124.4e-3
rk3862 n1170__i0__i14__net1 n1171__i0__i14__net1 3.1
rk3863 n1170__i0__i14__net1 n1174__i0__i14__net1 3.1
rk3864 n1170__i0__i14__net1 n1177__i0__i14__net1 3.1
rk3865 n1170__i0__i14__net1 n1180__i0__i14__net1 3.1
rk3867 n1185__i0__i14__net1 n1186__i0__i14__net1 12.37e-3
rk3868 n1186__i0__i14__net1 n1187__i0__i14__net1 360.5e-3
rk3869 n1187__i0__i14__net1 n1188__i0__i14__net1 223.4e-3
rk3870 n1188__i0__i14__net1 n1189__i0__i14__net1 114.8e-3
rk3871 n1189__i0__i14__net1 n1190__i0__i14__net1 360.5e-3
rk3872 n1190__i0__i14__net1 n1191__i0__i14__net1 239.3e-3
rk3873 n1191__i0__i14__net1 n1192__i0__i14__net1 118e-3
rk3875 n1184__i0__i14__net1 n1185__i0__i14__net1 5.7692
rk3876 n1184__i0__i14__net1 n1188__i0__i14__net1 3.75
rk3877 n1184__i0__i14__net1 n1191__i0__i14__net1 3.75
rk3881 n1311__vddio n1313__vddio 29.7e-3
rk3882 n1313__vddio n1314__vddio 330.8e-3
rk3883 n1314__vddio n1315__vddio 338.1e-3
rk3884 n1315__vddio n1316__vddio 42.07e-3
rk3885 n1316__vddio n1317__vddio 316.6e-3
rk3886 n1317__vddio n1318__vddio 357.3e-3
rk3887 n1318__vddio n1319__vddio 39.59e-3
rk3888 n1319__vddio n1320__vddio 319.1e-3
rk3889 n1320__vddio n1321__vddio 338.1e-3
rk3890 n1321__vddio n1322__vddio 51.97e-3
rk3891 n1322__vddio n1323__vddio 389.7e-3
rk3892 n1312__vddio n1313__vddio 3.1
rk3893 n1312__vddio n1316__vddio 3.1
rk3894 n1312__vddio n1319__vddio 3.1
rk3895 n1312__vddio n1322__vddio 3.1
rk3896 n924__vss n925__vss 54.44e-3
rk3897 n925__vss n926__vss 360.5e-3
rk3898 n926__vss n927__vss 294.3e-3
rk3899 n927__vss n928__vss 42.07e-3
rk3900 n928__vss n929__vss 360.5e-3
rk3901 n929__vss n930__vss 185e-3
rk3902 n930__vss n931__vss 262e-3
rk3903 n923__vss n924__vss 3.75
rk3904 n923__vss n927__vss 3.75
rk3905 n923__vss n930__vss 5.7692
rk3906 n122__i0__net2 n201__i0__net2 125e-3
rk3907 n124__i0__net2 n202__i0__net2 125e-3
rk3909 n1208__i0__i14__net1 n1210__i0__i14__net1 207.4e-3
rk3910 n1210__i0__i14__net1 n1211__i0__i14__net1 153.1e-3
rk3911 n1211__i0__i14__net1 n1212__i0__i14__net1 338.1e-3
rk3912 n1212__i0__i14__net1 n1213__i0__i14__net1 223.4e-3
rk3913 n1213__i0__i14__net1 n1214__i0__i14__net1 137.1e-3
rk3914 n1214__i0__i14__net1 n1215__i0__i14__net1 357.3e-3
rk3915 n1215__i0__i14__net1 n1216__i0__i14__net1 220.2e-3
rk3916 n1216__i0__i14__net1 n1217__i0__i14__net1 140.3e-3
rk3917 n1217__i0__i14__net1 n1218__i0__i14__net1 338.1e-3
rk3918 n1218__i0__i14__net1 n1219__i0__i14__net1 236.1e-3
rk3919 n1219__i0__i14__net1 n1220__i0__i14__net1 124.4e-3
rk3921 n1209__i0__i14__net1 n1210__i0__i14__net1 3.1
rk3922 n1209__i0__i14__net1 n1213__i0__i14__net1 3.1
rk3923 n1209__i0__i14__net1 n1216__i0__i14__net1 3.1
rk3924 n1209__i0__i14__net1 n1219__i0__i14__net1 3.1
rk3926 n1224__i0__i14__net1 n1225__i0__i14__net1 12.37e-3
rk3927 n1225__i0__i14__net1 n1226__i0__i14__net1 360.5e-3
rk3928 n1226__i0__i14__net1 n1227__i0__i14__net1 223.4e-3
rk3929 n1227__i0__i14__net1 n1228__i0__i14__net1 114.8e-3
rk3930 n1228__i0__i14__net1 n1229__i0__i14__net1 360.5e-3
rk3931 n1229__i0__i14__net1 n1230__i0__i14__net1 239.3e-3
rk3932 n1230__i0__i14__net1 n1231__i0__i14__net1 118e-3
rk3934 n1223__i0__i14__net1 n1224__i0__i14__net1 5.7692
rk3935 n1223__i0__i14__net1 n1227__i0__i14__net1 3.75
rk3936 n1223__i0__i14__net1 n1230__i0__i14__net1 3.75
rk3937 n134__i0__net2 n205__i0__net2 125e-3
rk3938 n136__i0__net2 n206__i0__net2 125e-3
rk3940 n1332__vddio n1334__vddio 29.7e-3
rk3941 n1334__vddio n1335__vddio 330.8e-3
rk3942 n1335__vddio n1336__vddio 338.1e-3
rk3943 n1336__vddio n1337__vddio 42.07e-3
rk3944 n1337__vddio n1338__vddio 316.6e-3
rk3945 n1338__vddio n1339__vddio 357.3e-3
rk3946 n1339__vddio n1340__vddio 39.59e-3
rk3947 n1340__vddio n1341__vddio 319.1e-3
rk3948 n1341__vddio n1342__vddio 338.1e-3
rk3949 n1342__vddio n1343__vddio 51.97e-3
rk3950 n1343__vddio n1344__vddio 389.7e-3
rk3951 n1333__vddio n1334__vddio 3.1
rk3952 n1333__vddio n1337__vddio 3.1
rk3953 n1333__vddio n1340__vddio 3.1
rk3954 n1333__vddio n1343__vddio 3.1
rk3955 n937__vss n938__vss 54.44e-3
rk3956 n938__vss n939__vss 360.5e-3
rk3957 n939__vss n940__vss 294.3e-3
rk3958 n940__vss n941__vss 42.07e-3
rk3959 n941__vss n942__vss 360.5e-3
rk3960 n942__vss n943__vss 185e-3
rk3961 n943__vss n944__vss 262e-3
rk3962 n936__vss n937__vss 3.75
rk3963 n936__vss n940__vss 3.75
rk3964 n936__vss n943__vss 5.7692
rk3965 n138__i0__net2 n209__i0__net2 125e-3
rk3966 n140__i0__net2 n210__i0__net2 125e-3
rk3968 n1248__i0__i14__net1 n1249__i0__i14__net1 12.37e-3
rk3969 n1249__i0__i14__net1 n1250__i0__i14__net1 360.5e-3
rk3970 n1250__i0__i14__net1 n1251__i0__i14__net1 223.4e-3
rk3971 n1251__i0__i14__net1 n1252__i0__i14__net1 114.8e-3
rk3972 n1252__i0__i14__net1 n1253__i0__i14__net1 360.5e-3
rk3973 n1253__i0__i14__net1 n1254__i0__i14__net1 239.3e-3
rk3974 n1254__i0__i14__net1 n1255__i0__i14__net1 118e-3
rk3976 n1247__i0__i14__net1 n1248__i0__i14__net1 5.7692
rk3977 n1247__i0__i14__net1 n1251__i0__i14__net1 3.75
rk3978 n1247__i0__i14__net1 n1254__i0__i14__net1 3.75
rk3980 n1258__i0__i14__net1 n1260__i0__i14__net1 207.4e-3
rk3981 n1260__i0__i14__net1 n1261__i0__i14__net1 153.1e-3
rk3982 n1261__i0__i14__net1 n1262__i0__i14__net1 338.1e-3
rk3983 n1262__i0__i14__net1 n1263__i0__i14__net1 223.4e-3
rk3984 n1263__i0__i14__net1 n1264__i0__i14__net1 137.1e-3
rk3985 n1264__i0__i14__net1 n1265__i0__i14__net1 357.3e-3
rk3986 n1265__i0__i14__net1 n1266__i0__i14__net1 220.2e-3
rk3987 n1266__i0__i14__net1 n1267__i0__i14__net1 140.3e-3
rk3988 n1267__i0__i14__net1 n1268__i0__i14__net1 338.1e-3
rk3989 n1268__i0__i14__net1 n1269__i0__i14__net1 236.1e-3
rk3990 n1269__i0__i14__net1 n1270__i0__i14__net1 124.4e-3
rk3992 n1259__i0__i14__net1 n1260__i0__i14__net1 3.1
rk3993 n1259__i0__i14__net1 n1263__i0__i14__net1 3.1
rk3994 n1259__i0__i14__net1 n1266__i0__i14__net1 3.1
rk3995 n1259__i0__i14__net1 n1269__i0__i14__net1 3.1
rk3996 n150__i0__net2 n213__i0__net2 125e-3
rk3997 n152__i0__net2 n214__i0__net2 125e-3
rk3998 n950__vss n951__vss 54.44e-3
rk3999 n951__vss n952__vss 360.5e-3
rk4000 n952__vss n953__vss 294.3e-3
rk4001 n953__vss n954__vss 42.07e-3
rk4002 n954__vss n955__vss 360.5e-3
rk4003 n955__vss n956__vss 185e-3
rk4004 n956__vss n957__vss 262e-3
rk4005 n949__vss n950__vss 3.75
rk4006 n949__vss n953__vss 3.75
rk4007 n949__vss n956__vss 5.7692
rk4009 n1353__vddio n1355__vddio 29.7e-3
rk4010 n1355__vddio n1356__vddio 330.8e-3
rk4011 n1356__vddio n1357__vddio 338.1e-3
rk4012 n1357__vddio n1358__vddio 42.07e-3
rk4013 n1358__vddio n1359__vddio 316.6e-3
rk4014 n1359__vddio n1360__vddio 357.3e-3
rk4015 n1360__vddio n1361__vddio 39.59e-3
rk4016 n1361__vddio n1362__vddio 319.1e-3
rk4017 n1362__vddio n1363__vddio 338.1e-3
rk4018 n1363__vddio n1364__vddio 51.97e-3
rk4019 n1364__vddio n1365__vddio 389.7e-3
rk4020 n1354__vddio n1355__vddio 3.1
rk4021 n1354__vddio n1358__vddio 3.1
rk4022 n1354__vddio n1361__vddio 3.1
rk4023 n1354__vddio n1364__vddio 3.1
rk4024 n154__i0__net2 n217__i0__net2 125e-3
rk4025 n156__i0__net2 n218__i0__net2 125e-3
rk4027 n1287__i0__i14__net1 n1288__i0__i14__net1 12.37e-3
rk4028 n1288__i0__i14__net1 n1289__i0__i14__net1 360.5e-3
rk4029 n1289__i0__i14__net1 n1290__i0__i14__net1 223.4e-3
rk4030 n1290__i0__i14__net1 n1291__i0__i14__net1 114.8e-3
rk4031 n1291__i0__i14__net1 n1292__i0__i14__net1 360.5e-3
rk4032 n1292__i0__i14__net1 n1293__i0__i14__net1 239.3e-3
rk4033 n1293__i0__i14__net1 n1294__i0__i14__net1 118e-3
rk4035 n1286__i0__i14__net1 n1287__i0__i14__net1 5.7692
rk4036 n1286__i0__i14__net1 n1290__i0__i14__net1 3.75
rk4037 n1286__i0__i14__net1 n1293__i0__i14__net1 3.75
rk4039 n1297__i0__i14__net1 n1299__i0__i14__net1 207.4e-3
rk4040 n1299__i0__i14__net1 n1300__i0__i14__net1 153.1e-3
rk4041 n1300__i0__i14__net1 n1301__i0__i14__net1 338.1e-3
rk4042 n1301__i0__i14__net1 n1302__i0__i14__net1 223.4e-3
rk4043 n1302__i0__i14__net1 n1303__i0__i14__net1 137.1e-3
rk4044 n1303__i0__i14__net1 n1304__i0__i14__net1 357.3e-3
rk4045 n1304__i0__i14__net1 n1305__i0__i14__net1 220.2e-3
rk4046 n1305__i0__i14__net1 n1306__i0__i14__net1 140.3e-3
rk4047 n1306__i0__i14__net1 n1307__i0__i14__net1 338.1e-3
rk4048 n1307__i0__i14__net1 n1308__i0__i14__net1 236.1e-3
rk4049 n1308__i0__i14__net1 n1309__i0__i14__net1 124.4e-3
rk4051 n1298__i0__i14__net1 n1299__i0__i14__net1 3.1
rk4052 n1298__i0__i14__net1 n1302__i0__i14__net1 3.1
rk4053 n1298__i0__i14__net1 n1305__i0__i14__net1 3.1
rk4054 n1298__i0__i14__net1 n1308__i0__i14__net1 3.1
rk4057 n963__vss n964__vss 54.44e-3
rk4058 n964__vss n965__vss 360.5e-3
rk4059 n965__vss n966__vss 294.3e-3
rk4060 n966__vss n967__vss 42.07e-3
rk4061 n967__vss n968__vss 360.5e-3
rk4062 n968__vss n969__vss 185e-3
rk4063 n969__vss n970__vss 262e-3
rk4064 n962__vss n963__vss 3.75
rk4065 n962__vss n966__vss 3.75
rk4066 n962__vss n969__vss 5.7692
rk4068 n1374__vddio n1376__vddio 29.7e-3
rk4069 n1376__vddio n1377__vddio 330.8e-3
rk4070 n1377__vddio n1378__vddio 338.1e-3
rk4071 n1378__vddio n1379__vddio 42.07e-3
rk4072 n1379__vddio n1380__vddio 316.6e-3
rk4073 n1380__vddio n1381__vddio 357.3e-3
rk4074 n1381__vddio n1382__vddio 39.59e-3
rk4075 n1382__vddio n1383__vddio 319.1e-3
rk4076 n1383__vddio n1384__vddio 338.1e-3
rk4077 n1384__vddio n1385__vddio 51.97e-3
rk4078 n1385__vddio n1386__vddio 389.7e-3
rk4079 n1375__vddio n1376__vddio 3.1
rk4080 n1375__vddio n1379__vddio 3.1
rk4081 n1375__vddio n1382__vddio 3.1
rk4082 n1375__vddio n1385__vddio 3.1
rk4083 n975__vss n976__vss 25e-3
rk4084 n976__vss n977__vss 71.14e-3
rk4085 n977__vss n978__vss 63.45e-3
rk4086 n978__vss n979__vss 90.37e-3
rk4087 n979__vss n980__vss 89.09e-3
rk4088 n980__vss n981__vss 64.73e-3
rk4089 n981__vss n982__vss 114.7e-3
rk4090 n982__vss n983__vss 39.1e-3
rk4091 n983__vss n984__vss 140.4e-3
rk4092 n984__vss n985__vss 13.46e-3
rk4093 n985__vss n986__vss 153.8e-3
rk4094 n986__vss n987__vss 12.18e-3
rk4095 n987__vss n988__vss 141.6e-3
rk4096 n988__vss n989__vss 37.81e-3
rk4097 n989__vss n990__vss 116e-3
rk4098 n990__vss n991__vss 63.45e-3
rk4099 n991__vss n992__vss 90.37e-3
rk4100 n992__vss n993__vss 89.09e-3
rk4101 n993__vss n994__vss 64.73e-3
rk4102 n994__vss n995__vss 114.7e-3
rk4103 n995__vss n996__vss 39.1e-3
rk4104 n996__vss n997__vss 140.4e-3
rk4105 n997__vss n998__vss 13.46e-3
rk4106 n998__vss n999__vss 153.8e-3
rk4107 n999__vss n1000__vss 12.18e-3
rk4108 n1000__vss n1001__vss 141.6e-3
rk4109 n1001__vss n1002__vss 37.81e-3
rk4110 n1002__vss n1003__vss 116e-3
rk4111 n1003__vss n1004__vss 63.45e-3
rk4112 n1004__vss n1005__vss 90.37e-3
rk4113 n1005__vss n1006__vss 89.09e-3
rk4114 n1006__vss n1007__vss 64.73e-3
rk4115 n1007__vss n1008__vss 114.7e-3
rk4116 n1008__vss n1009__vss 39.1e-3
rk4117 n1009__vss n1010__vss 140.4e-3
rk4118 n1010__vss n573__vss 530.1e-3
rk4119 n573__vss n975__vss 2.0667
rk4120 n573__vss n977__vss 516.7e-3
rk4121 n573__vss n979__vss 516.7e-3
rk4122 n573__vss n981__vss 516.7e-3
rk4123 n573__vss n983__vss 516.7e-3
rk4124 n573__vss n985__vss 516.7e-3
rk4125 n573__vss n986__vss 516.7e-3
rk4126 n573__vss n988__vss 516.7e-3
rk4127 n573__vss n990__vss 516.7e-3
rk4128 n573__vss n992__vss 516.7e-3
rk4129 n573__vss n994__vss 516.7e-3
rk4130 n573__vss n996__vss 516.7e-3
rk4131 n573__vss n998__vss 516.7e-3
rk4132 n573__vss n999__vss 516.7e-3
rk4133 n573__vss n1001__vss 516.7e-3
rk4134 n573__vss n1003__vss 516.7e-3
rk4135 n573__vss n1005__vss 516.7e-3
rk4136 n573__vss n1007__vss 516.7e-3
rk4137 n573__vss n1009__vss 516.7e-3
rk4138 n1395__vddio n1396__vddio 25e-3
rk4139 n1396__vddio n1397__vddio 71.14e-3
rk4140 n1397__vddio n1398__vddio 63.45e-3
rk4141 n1398__vddio n1399__vddio 90.37e-3
rk4142 n1399__vddio n1400__vddio 89.09e-3
rk4143 n1400__vddio n1401__vddio 64.73e-3
rk4144 n1401__vddio n1402__vddio 114.7e-3
rk4145 n1402__vddio n1403__vddio 39.1e-3
rk4146 n1403__vddio n1404__vddio 140.4e-3
rk4147 n1404__vddio n1405__vddio 13.46e-3
rk4148 n1405__vddio n1406__vddio 153.8e-3
rk4149 n1406__vddio n1407__vddio 12.18e-3
rk4150 n1407__vddio n1408__vddio 141.6e-3
rk4151 n1408__vddio n1409__vddio 37.81e-3
rk4152 n1409__vddio n1410__vddio 116e-3
rk4153 n1410__vddio n1411__vddio 63.45e-3
rk4154 n1411__vddio n1412__vddio 90.37e-3
rk4155 n1412__vddio n1413__vddio 89.09e-3
rk4156 n1413__vddio n1414__vddio 64.73e-3
rk4157 n1414__vddio n1415__vddio 114.7e-3
rk4158 n1415__vddio n1416__vddio 39.1e-3
rk4159 n1416__vddio n1417__vddio 140.4e-3
rk4160 n1417__vddio n1418__vddio 13.46e-3
rk4161 n1418__vddio n1419__vddio 153.8e-3
rk4162 n1419__vddio n1420__vddio 12.18e-3
rk4163 n1420__vddio n1421__vddio 141.6e-3
rk4164 n1421__vddio n1422__vddio 37.81e-3
rk4165 n1422__vddio n1423__vddio 116e-3
rk4166 n1423__vddio n1424__vddio 63.45e-3
rk4167 n1424__vddio n1425__vddio 90.37e-3
rk4168 n1425__vddio n1426__vddio 89.09e-3
rk4169 n1426__vddio n1427__vddio 64.73e-3
rk4170 n1427__vddio n1428__vddio 114.7e-3
rk4171 n1428__vddio n1429__vddio 39.1e-3
rk4172 n1429__vddio n1430__vddio 140.4e-3
rk4173 n1430__vddio n1394__vddio 638.5e-3
rk4174 n1394__vddio n1395__vddio 2.5
rk4175 n1394__vddio n1397__vddio 625e-3
rk4176 n1394__vddio n1399__vddio 625e-3
rk4177 n1394__vddio n1401__vddio 625e-3
rk4178 n1394__vddio n1403__vddio 625e-3
rk4179 n1394__vddio n1405__vddio 625e-3
rk4180 n1394__vddio n1406__vddio 625e-3
rk4181 n1394__vddio n1408__vddio 625e-3
rk4182 n1394__vddio n1410__vddio 625e-3
rk4183 n1394__vddio n1412__vddio 625e-3
rk4184 n1394__vddio n1414__vddio 625e-3
rk4185 n1394__vddio n1416__vddio 625e-3
rk4186 n1394__vddio n1418__vddio 625e-3
rk4187 n1394__vddio n1419__vddio 625e-3
rk4188 n1394__vddio n1421__vddio 625e-3
rk4189 n1394__vddio n1423__vddio 625e-3
rk4190 n1394__vddio n1425__vddio 625e-3
rk4191 n1394__vddio n1427__vddio 625e-3
rk4192 n1394__vddio n1429__vddio 625e-3
rk4193 n231__i0__net2 n232__i0__net2 318.5e-3
rk4194 n232__i0__net2 n234__i0__net2 146.2e-3
rk4195 n231__i0__net2 n233__i0__net2 5.2284
rk4196 n234__i0__net2 n235__i0__net2 269.1e-3
rk4197 n233__i0__net2 n234__i0__net2 3.1
rk4198 n236__i0__net2 n237__i0__net2 75.2887
rk4199 n237__i0__net2 n238__i0__net2 68.32e-3
rk4200 n238__i0__net2 n239__i0__net2 348.1e-3
rk4201 n236__i0__net2 n238__i0__net2 3.75
rk4202 n4__i0__i13__net1 n57__i0__i13__net1 125e-3
rk4203 n2__i0__i13__net1 n58__i0__i13__net1 125e-3
rk4204 n1538__vddio n1540__vddio 185.8e-3
rk4205 n1540__vddio n1541__vddio 227.6e-3
rk4206 n1541__vddio n1542__vddio 311.7e-3
rk4207 n1542__vddio n1543__vddio 27.22e-3
rk4208 n1543__vddio n1544__vddio 327.6e-3
rk4209 n1539__vddio n1540__vddio 5.1667
rk4210 n1539__vddio n1542__vddio 3.1
rk4211 n1114__vss n1116__vss 43.65e-3
rk4212 n1116__vss n1117__vss 120e-3
rk4213 n1117__vss n1118__vss 237.1e-3
rk4214 n1118__vss n1119__vss 101.8e-3
rk4216 n1115__vss n1116__vss 75
rk4217 n1115__vss n1118__vss 3.75
rk4218 n8__i0__i13__net1 n69__i0__i13__net1 125e-3
rk4219 n6__i0__i13__net1 n70__i0__i13__net1 125e-3
rk4220 n240__i0__net2 n241__i0__net2 75.2887
rk4221 n241__i0__net2 n242__i0__net2 68.32e-3
rk4222 n242__i0__net2 n243__i0__net2 348.1e-3
rk4223 n240__i0__net2 n242__i0__net2 3.75
rk4224 n244__i0__net2 n245__i0__net2 318.5e-3
rk4225 n245__i0__net2 n247__i0__net2 146.2e-3
rk4226 n244__i0__net2 n246__i0__net2 5.2284
rk4227 n247__i0__net2 n248__i0__net2 269.1e-3
rk4228 n246__i0__net2 n247__i0__net2 3.1
rk4229 n12__i0__i13__net1 n73__i0__i13__net1 125e-3
rk4230 n10__i0__i13__net1 n74__i0__i13__net1 125e-3
rk4231 n1121__vss n1123__vss 237.1e-3
rk4232 n1121__vss n1124__vss 113.7e-3
rk4233 n1124__vss n1125__vss 170.7e-3
rk4234 n1123__vss n1126__vss 184e-3
rk4235 n1122__vss n1123__vss 3.75
rk4236 n1122__vss n1124__vss 75
rk4237 n1545__vddio n1547__vddio 185.8e-3
rk4238 n1547__vddio n1548__vddio 227.6e-3
rk4239 n1548__vddio n1549__vddio 311.7e-3
rk4240 n1549__vddio n1550__vddio 27.22e-3
rk4241 n1550__vddio n1551__vddio 327.6e-3
rk4242 n1546__vddio n1547__vddio 5.1667
rk4243 n1546__vddio n1549__vddio 3.1
rk4244 n16__i0__i13__net1 n85__i0__i13__net1 125e-3
rk4245 n14__i0__i13__net1 n86__i0__i13__net1 125e-3
rk4246 n249__i0__net2 n250__i0__net2 318.5e-3
rk4247 n250__i0__net2 n252__i0__net2 146.2e-3
rk4248 n249__i0__net2 n251__i0__net2 5.2284
rk4249 n252__i0__net2 n253__i0__net2 269.1e-3
rk4250 n251__i0__net2 n252__i0__net2 3.1
rk4251 n254__i0__net2 n255__i0__net2 75.2887
rk4252 n255__i0__net2 n256__i0__net2 68.32e-3
rk4253 n256__i0__net2 n257__i0__net2 348.1e-3
rk4254 n254__i0__net2 n256__i0__net2 3.75
rk4255 n20__i0__i13__net1 n89__i0__i13__net1 125e-3
rk4256 n18__i0__i13__net1 n90__i0__i13__net1 125e-3
rk4257 n1552__vddio n1554__vddio 185.8e-3
rk4258 n1554__vddio n1555__vddio 227.6e-3
rk4259 n1555__vddio n1556__vddio 311.7e-3
rk4260 n1556__vddio n1557__vddio 27.22e-3
rk4261 n1557__vddio n1558__vddio 326e-3
rk4262 n1553__vddio n1554__vddio 5.1667
rk4263 n1553__vddio n1556__vddio 3.1
rk4264 n1127__vss n1129__vss 237.1e-3
rk4265 n1127__vss n1130__vss 116.2e-3
rk4266 n1130__vss n1131__vss 168.1e-3
rk4267 n1129__vss n1132__vss 184e-3
rk4268 n1128__vss n1129__vss 3.75
rk4269 n1128__vss n1130__vss 75
rk4270 n24__i0__i13__net1 n97__i0__i13__net1 125e-3
rk4271 n22__i0__i13__net1 n98__i0__i13__net1 125e-3
rk4272 n258__i0__net2 n259__i0__net2 318.5e-3
rk4273 n259__i0__net2 n261__i0__net2 146.2e-3
rk4274 n258__i0__net2 n260__i0__net2 5.2284
rk4275 n261__i0__net2 n262__i0__net2 269.1e-3
rk4276 n260__i0__net2 n261__i0__net2 3.1
rk4277 n263__i0__net2 n264__i0__net2 75.2887
rk4278 n264__i0__net2 n265__i0__net2 68.32e-3
rk4279 n265__i0__net2 n266__i0__net2 348.1e-3
rk4280 n263__i0__net2 n265__i0__net2 3.75
rk4283 n1559__vddio n1561__vddio 185.8e-3
rk4284 n1561__vddio n1562__vddio 227.6e-3
rk4285 n1562__vddio n1563__vddio 311.7e-3
rk4286 n1563__vddio n1564__vddio 27.22e-3
rk4287 n1564__vddio n1565__vddio 327.6e-3
rk4288 n1560__vddio n1561__vddio 5.1667
rk4289 n1560__vddio n1563__vddio 3.1
rk4290 n1134__vss n1135__vss 120e-3
rk4291 n1135__vss n1136__vss 237.1e-3
rk4292 n1136__vss n1137__vss 101.8e-3
rk4294 n1134__vss n1139__vss 171.6e-3
rk4295 n1133__vss n1134__vss 75
rk4296 n1133__vss n1136__vss 3.75
rk4299 n267__i0__net2 n268__i0__net2 318.5e-3
rk4300 n268__i0__net2 n270__i0__net2 146.2e-3
rk4301 n267__i0__net2 n269__i0__net2 5.2284
rk4302 n270__i0__net2 n271__i0__net2 269.1e-3
rk4303 n269__i0__net2 n270__i0__net2 3.1
rk4304 n272__i0__net2 n273__i0__net2 75.2887
rk4305 n273__i0__net2 n274__i0__net2 68.32e-3
rk4306 n274__i0__net2 n275__i0__net2 348.1e-3
rk4307 n272__i0__net2 n274__i0__net2 3.75
rk4308 n35__i0__i13__net1 n113__i0__i13__net1 125e-3
rk4309 n34__i0__i13__net1 n114__i0__i13__net1 125e-3
rk4310 n1566__vddio n1567__vddio 454.5e-3
rk4311 n1567__vddio n1569__vddio 27.22e-3
rk4312 n1569__vddio n1570__vddio 311.7e-3
rk4313 n1570__vddio n1571__vddio 227.6e-3
rk4314 n1571__vddio n1572__vddio 185.8e-3
rk4315 n1568__vddio n1569__vddio 3.1
rk4316 n1568__vddio n1571__vddio 5.1667
rk4317 n1140__vss n1142__vss 116.2e-3
rk4318 n1142__vss n1143__vss 83.61e-3
rk4319 n1140__vss n1144__vss 237.1e-3
rk4320 n1144__vss n1145__vss 184e-3
rk4321 n1141__vss n1142__vss 75
rk4322 n1141__vss n1144__vss 3.75
rk4323 n40__i0__i13__net1 n117__i0__i13__net1 125e-3
rk4324 n38__i0__i13__net1 n118__i0__i13__net1 125e-3
rk4325 n276__i0__net2 n277__i0__net2 318.5e-3
rk4326 n277__i0__net2 n279__i0__net2 146.2e-3
rk4327 n276__i0__net2 n278__i0__net2 5.2284
rk4328 n279__i0__net2 n280__i0__net2 269.1e-3
rk4329 n278__i0__net2 n279__i0__net2 3.1
rk4330 n281__i0__net2 n282__i0__net2 75.2887
rk4331 n282__i0__net2 n283__i0__net2 68.32e-3
rk4332 n283__i0__net2 n284__i0__net2 348.1e-3
rk4333 n281__i0__net2 n283__i0__net2 3.75
rk4334 n43__i0__i13__net1 n125__i0__i13__net1 125e-3
rk4335 n42__i0__i13__net1 n126__i0__i13__net1 125e-3
rk4336 n1573__vddio n1575__vddio 185.8e-3
rk4337 n1575__vddio n1576__vddio 227.6e-3
rk4338 n1576__vddio n1577__vddio 311.7e-3
rk4339 n1577__vddio n1578__vddio 27.22e-3
rk4340 n1578__vddio n1579__vddio 323e-3
rk4341 n1574__vddio n1575__vddio 5.1667
rk4342 n1574__vddio n1577__vddio 3.1
rk4343 n1146__vss n1148__vss 237.1e-3
rk4344 n1146__vss n1149__vss 116.2e-3
rk4345 n1149__vss n1150__vss 171e-3
rk4346 n1148__vss n1151__vss 184e-3
rk4347 n1147__vss n1148__vss 3.75
rk4348 n1147__vss n1149__vss 75
rk4349 n48__i0__i13__net1 n129__i0__i13__net1 125e-3
rk4350 n46__i0__i13__net1 n130__i0__i13__net1 125e-3
rk4351 n285__i0__net2 n286__i0__net2 318.5e-3
rk4352 n286__i0__net2 n288__i0__net2 146.2e-3
rk4353 n285__i0__net2 n287__i0__net2 5.2284
rk4354 n288__i0__net2 n289__i0__net2 269.1e-3
rk4355 n287__i0__net2 n288__i0__net2 3.1
rk4356 n290__i0__net2 n291__i0__net2 75.2887
rk4357 n291__i0__net2 n292__i0__net2 68.32e-3
rk4358 n292__i0__net2 n293__i0__net2 348.1e-3
rk4359 n290__i0__net2 n292__i0__net2 3.75
rk4360 n51__i0__i13__net1 n133__i0__i13__net1 125e-3
rk4361 n50__i0__i13__net1 n134__i0__i13__net1 125e-3
rk4362 n1580__vddio n1582__vddio 185.8e-3
rk4363 n1582__vddio n1583__vddio 227.6e-3
rk4364 n1583__vddio n1584__vddio 311.7e-3
rk4365 n1584__vddio n1585__vddio 27.22e-3
rk4366 n1585__vddio n1586__vddio 327.6e-3
rk4367 n1581__vddio n1582__vddio 5.1667
rk4368 n1581__vddio n1584__vddio 3.1
rk4369 n1152__vss n1154__vss 43.65e-3
rk4370 n1154__vss n1155__vss 120e-3
rk4371 n1155__vss n1156__vss 237.1e-3
rk4372 n1156__vss n1157__vss 101.8e-3
rk4374 n1153__vss n1154__vss 75
rk4375 n1153__vss n1156__vss 3.75
rk4376 n56__i0__i13__net1 n137__i0__i13__net1 125e-3
rk4377 n54__i0__i13__net1 n138__i0__i13__net1 125e-3
rk4378 n294__i0__net2 n295__i0__net2 318.5e-3
rk4379 n295__i0__net2 n297__i0__net2 146.2e-3
rk4380 n294__i0__net2 n296__i0__net2 5.2284
rk4381 n297__i0__net2 n298__i0__net2 269.1e-3
rk4382 n296__i0__net2 n297__i0__net2 3.1
rk4383 n299__i0__net2 n300__i0__net2 75.2887
rk4384 n300__i0__net2 n301__i0__net2 68.32e-3
rk4385 n301__i0__net2 n302__i0__net2 348.1e-3
rk4386 n299__i0__net2 n301__i0__net2 3.75
rk4387 n63__i0__i13__net1 n141__i0__i13__net1 125e-3
rk4388 n62__i0__i13__net1 n142__i0__i13__net1 125e-3
rk4389 n1587__vddio n1589__vddio 185.8e-3
rk4390 n1589__vddio n1590__vddio 227.6e-3
rk4391 n1590__vddio n1591__vddio 311.7e-3
rk4392 n1591__vddio n1592__vddio 27.22e-3
rk4393 n1592__vddio n1593__vddio 323e-3
rk4394 n1588__vddio n1589__vddio 5.1667
rk4395 n1588__vddio n1591__vddio 3.1
rk4396 n1160__vss n1161__vss 120e-3
rk4397 n1161__vss n1162__vss 237.1e-3
rk4398 n1162__vss n1163__vss 101.8e-3
rk4400 n1160__vss n1165__vss 171.6e-3
rk4401 n1159__vss n1160__vss 75
rk4402 n1159__vss n1162__vss 3.75
rk4405 n303__i0__net2 n304__i0__net2 318.5e-3
rk4406 n304__i0__net2 n306__i0__net2 146.2e-3
rk4407 n303__i0__net2 n305__i0__net2 5.2284
rk4408 n306__i0__net2 n307__i0__net2 269.1e-3
rk4409 n305__i0__net2 n306__i0__net2 3.1
rk4410 n308__i0__net2 n309__i0__net2 75.2887
rk4411 n309__i0__net2 n310__i0__net2 68.32e-3
rk4412 n310__i0__net2 n311__i0__net2 348.1e-3
rk4413 n308__i0__net2 n310__i0__net2 3.75
rk4414 n79__i0__i13__net1 n149__i0__i13__net1 125e-3
rk4415 n78__i0__i13__net1 n150__i0__i13__net1 125e-3
rk4416 n1594__vddio n1596__vddio 185.8e-3
rk4417 n1596__vddio n1597__vddio 227.6e-3
rk4418 n1597__vddio n1598__vddio 311.7e-3
rk4419 n1598__vddio n1599__vddio 27.22e-3
rk4420 n1599__vddio n1600__vddio 327.6e-3
rk4421 n1595__vddio n1596__vddio 5.1667
rk4422 n1595__vddio n1598__vddio 3.1
rk4423 n1166__vss n1168__vss 116.2e-3
rk4424 n1168__vss n1169__vss 83.61e-3
rk4425 n1166__vss n1170__vss 237.1e-3
rk4426 n1170__vss n1171__vss 184e-3
rk4427 n1167__vss n1168__vss 75
rk4428 n1167__vss n1170__vss 3.75
rk4429 n84__i0__i13__net1 n151__i0__i13__net1 125e-3
rk4430 n82__i0__i13__net1 n152__i0__i13__net1 125e-3
rk4431 n312__i0__net2 n313__i0__net2 75.2887
rk4432 n313__i0__net2 n314__i0__net2 68.32e-3
rk4433 n314__i0__net2 n315__i0__net2 348.1e-3
rk4434 n312__i0__net2 n314__i0__net2 3.75
rk4435 n316__i0__net2 n317__i0__net2 318.5e-3
rk4436 n317__i0__net2 n319__i0__net2 146.2e-3
rk4437 n316__i0__net2 n318__i0__net2 5.2284
rk4438 n319__i0__net2 n320__i0__net2 269.1e-3
rk4439 n318__i0__net2 n319__i0__net2 3.1
rk4440 n95__i0__i13__net1 n157__i0__i13__net1 125e-3
rk4441 n94__i0__i13__net1 n158__i0__i13__net1 125e-3
rk4442 n1172__vss n1174__vss 184e-3
rk4443 n1174__vss n1175__vss 237.1e-3
rk4444 n1175__vss n1176__vss 116.2e-3
rk4445 n1176__vss n1177__vss 171e-3
rk4446 n1173__vss n1174__vss 3.75
rk4447 n1173__vss n1176__vss 75
rk4448 n1601__vddio n1603__vddio 185.8e-3
rk4449 n1603__vddio n1604__vddio 227.6e-3
rk4450 n1604__vddio n1605__vddio 311.7e-3
rk4451 n1605__vddio n1606__vddio 27.22e-3
rk4452 n1606__vddio n1607__vddio 321.5e-3
rk4453 n1602__vddio n1603__vddio 5.1667
rk4454 n1602__vddio n1605__vddio 3.1
rk4455 n102__i0__i13__net1 n161__i0__i13__net1 125e-3
rk4456 n100__i0__i13__net1 n162__i0__i13__net1 125e-3
rk4457 n321__i0__net2 n322__i0__net2 75.2887
rk4458 n322__i0__net2 n323__i0__net2 68.32e-3
rk4459 n323__i0__net2 n324__i0__net2 348.1e-3
rk4460 n321__i0__net2 n323__i0__net2 3.75
rk4461 n325__i0__net2 n326__i0__net2 318.5e-3
rk4462 n326__i0__net2 n328__i0__net2 146.2e-3
rk4463 n325__i0__net2 n327__i0__net2 5.2284
rk4464 n328__i0__net2 n329__i0__net2 269.1e-3
rk4465 n327__i0__net2 n328__i0__net2 3.1
rk4466 n123__i0__i13__net1 n165__i0__i13__net1 125e-3
rk4467 n122__i0__i13__net1 n166__i0__i13__net1 125e-3
rk4468 n1608__vddio n1610__vddio 185.8e-3
rk4469 n1610__vddio n1611__vddio 227.6e-3
rk4470 n1611__vddio n1612__vddio 311.7e-3
rk4471 n1612__vddio n1613__vddio 27.22e-3
rk4472 n1613__vddio n1614__vddio 324.4e-3
rk4473 n1609__vddio n1610__vddio 5.1667
rk4474 n1609__vddio n1612__vddio 3.1
rk4475 n1178__vss n1180__vss 43.65e-3
rk4476 n1180__vss n1181__vss 120.8e-3
rk4477 n1181__vss n1182__vss 238e-3
rk4478 n1182__vss n1183__vss 102.6e-3
rk4480 n1179__vss n1180__vss 75
rk4481 n1179__vss n1182__vss 3.75
rk4482 n1186__vss n1187__vss 114.1e-3
rk4483 n1187__vss n1188__vss 242.9e-3
rk4484 n1188__vss n1189__vss 95.96e-3
rk4486 n1186__vss n1191__vss 177.4e-3
rk4487 n1185__vss n1186__vss 75
rk4488 n1185__vss n1188__vss 3.75
rk4489 n1615__vddio n1616__vddio 451.6e-3
rk4490 n1616__vddio n1618__vddio 24.75e-3
rk4491 n1618__vddio n1619__vddio 314.1e-3
rk4492 n1619__vddio n1620__vddio 224.7e-3
rk4493 n1620__vddio n1621__vddio 188.8e-3
rk4494 n1617__vddio n1618__vddio 3.1
rk4495 n1617__vddio n1620__vddio 5.1667
rk4496 n2__i0__net3 n25__i0__net3 125e-3
rk4497 n4__i0__net3 n26__i0__net3 125e-3
rk4498 n186__i0__i13__net1 n187__i0__i13__net1 75.2829
rk4499 n187__i0__i13__net1 n188__i0__i13__net1 74.14e-3
rk4500 n188__i0__i13__net1 n189__i0__i13__net1 342.3e-3
rk4501 n186__i0__i13__net1 n188__i0__i13__net1 3.75
rk4503 n191__i0__i13__net1 n193__i0__i13__net1 184e-3
rk4504 n193__i0__i13__net1 n194__i0__i13__net1 149.1e-3
rk4505 n194__i0__i13__net1 n195__i0__i13__net1 318.5e-3
rk4506 n195__i0__i13__net1 n196__i0__i13__net1 56.92e-3
rk4507 n192__i0__i13__net1 n193__i0__i13__net1 3.1
rk4508 n192__i0__i13__net1 n196__i0__i13__net1 5.1667
rk4509 n6__i0__net3 n29__i0__net3 125e-3
rk4510 n8__i0__net3 n30__i0__net3 125e-3
rk4511 n1192__vss n1194__vss 110.6e-3
rk4512 n1194__vss n1195__vss 94.76e-3
rk4513 n1192__vss n1196__vss 242.9e-3
rk4514 n1196__vss n1197__vss 178.2e-3
rk4515 n1193__vss n1194__vss 75
rk4516 n1193__vss n1196__vss 3.75
rk4517 n1622__vddio n1624__vddio 188.8e-3
rk4518 n1624__vddio n1625__vddio 224.7e-3
rk4519 n1625__vddio n1626__vddio 314.1e-3
rk4520 n1626__vddio n1627__vddio 24.75e-3
rk4521 n1627__vddio n1628__vddio 327.6e-3
rk4522 n1623__vddio n1624__vddio 5.1667
rk4523 n1623__vddio n1626__vddio 3.1
rk4524 n10__i0__net3 n31__i0__net3 125e-3
rk4525 n12__i0__net3 n32__i0__net3 125e-3
rk4526 n197__i0__i13__net1 n198__i0__i13__net1 75.2829
rk4527 n198__i0__i13__net1 n199__i0__i13__net1 74.14e-3
rk4528 n199__i0__i13__net1 n200__i0__i13__net1 342.3e-3
rk4529 n197__i0__i13__net1 n199__i0__i13__net1 3.75
rk4531 n202__i0__i13__net1 n204__i0__i13__net1 184e-3
rk4532 n204__i0__i13__net1 n205__i0__i13__net1 149.1e-3
rk4533 n205__i0__i13__net1 n206__i0__i13__net1 318.5e-3
rk4534 n206__i0__i13__net1 n207__i0__i13__net1 56.92e-3
rk4535 n203__i0__i13__net1 n204__i0__i13__net1 3.1
rk4536 n203__i0__i13__net1 n207__i0__i13__net1 5.1667
rk4539 n1198__vss n1200__vss 114.1e-3
rk4540 n1200__vss n1201__vss 177.1e-3
rk4541 n1198__vss n1202__vss 242.9e-3
rk4542 n1202__vss n1203__vss 178.2e-3
rk4543 n1199__vss n1200__vss 75
rk4544 n1199__vss n1202__vss 3.75
rk4545 n1629__vddio n1631__vddio 188.8e-3
rk4546 n1631__vddio n1632__vddio 224.7e-3
rk4547 n1632__vddio n1633__vddio 314.1e-3
rk4548 n1633__vddio n1634__vddio 24.75e-3
rk4549 n1634__vddio n1635__vddio 324.7e-3
rk4550 n1630__vddio n1631__vddio 5.1667
rk4551 n1630__vddio n1633__vddio 3.1
rk4552 n18__i0__net3 n41__i0__net3 125e-3
rk4553 n20__i0__net3 n42__i0__net3 125e-3
rk4554 n208__i0__i13__net1 n209__i0__i13__net1 75.2829
rk4555 n209__i0__i13__net1 n210__i0__i13__net1 74.14e-3
rk4556 n210__i0__i13__net1 n211__i0__i13__net1 342.3e-3
rk4557 n208__i0__i13__net1 n210__i0__i13__net1 3.75
rk4559 n213__i0__i13__net1 n215__i0__i13__net1 184e-3
rk4560 n215__i0__i13__net1 n216__i0__i13__net1 149.1e-3
rk4561 n216__i0__i13__net1 n217__i0__i13__net1 318.5e-3
rk4562 n217__i0__i13__net1 n218__i0__i13__net1 56.92e-3
rk4563 n214__i0__i13__net1 n215__i0__i13__net1 3.1
rk4564 n214__i0__i13__net1 n218__i0__i13__net1 5.1667
rk4565 n22__i0__net3 n45__i0__net3 125e-3
rk4566 n24__i0__net3 n46__i0__net3 125e-3
rk4567 n1205__vss n1206__vss 114.1e-3
rk4568 n1206__vss n1207__vss 242.9e-3
rk4569 n1207__vss n1208__vss 95.96e-3
rk4571 n1205__vss n1210__vss 174.5e-3
rk4572 n1204__vss n1205__vss 75
rk4573 n1204__vss n1207__vss 3.75
rk4574 n1636__vddio n1637__vddio 454.5e-3
rk4575 n1637__vddio n1639__vddio 24.75e-3
rk4576 n1639__vddio n1640__vddio 314.1e-3
rk4577 n1640__vddio n1641__vddio 224.7e-3
rk4578 n1641__vddio n1642__vddio 188.8e-3
rk4579 n1638__vddio n1639__vddio 3.1
rk4580 n1638__vddio n1641__vddio 5.1667
rk4581 n49__i0__net3 n50__i0__net3 15.125
rk4583 n53__i0__net3 n54__i0__net3 8.73e-3
rk4585 n52__i0__net3 n53__i0__net3 7.75
rk4586 n2__i0__i12__net1 n29__i0__i12__net1 125e-3
rk4587 n4__i0__i12__net1 n30__i0__i12__net1 125e-3
rk4588 n6__i0__i12__net1 n33__i0__i12__net1 125e-3
rk4589 n8__i0__i12__net1 n34__i0__i12__net1 125e-3
rk4590 n58__i0__net3 n60__i0__net3 25.08e-3
rk4591 n59__i0__net3 n60__i0__net3 15
rk4593 n63__i0__net3 n64__i0__net3 8.022e-3
rk4595 n62__i0__net3 n63__i0__net3 7.75
rk4596 n10__i0__i12__net1 n37__i0__i12__net1 125e-3
rk4597 n12__i0__i12__net1 n38__i0__i12__net1 125e-3
rk4598 n14__i0__i12__net1 n39__i0__i12__net1 125e-3
rk4599 n16__i0__i12__net1 n40__i0__i12__net1 125e-3
rk4600 n66__i0__net3 n67__i0__net3 15.126
rk4602 n70__i0__net3 n71__i0__net3 5.82e-3
rk4604 n69__i0__net3 n70__i0__net3 7.75
rk4605 n18__i0__i12__net1 n41__i0__i12__net1 125e-3
rk4606 n20__i0__i12__net1 n42__i0__i12__net1 125e-3
rk4607 n22__i0__i12__net1 n49__i0__i12__net1 125e-3
rk4608 n24__i0__i12__net1 n50__i0__i12__net1 125e-3
rk4610 n75__i0__net3 n76__i0__net3 8.73e-3
rk4612 n74__i0__net3 n75__i0__net3 7.75
rk4613 n78__i0__net3 n79__i0__net3 15.125
rk4616 n2__i0__net4 n13__i0__net4 125e-3
rk4617 n4__i0__net4 n14__i0__net4 125e-3
rk4619 n59__i0__i12__net1 n60__i0__i12__net1 148.3e-3
rk4620 n58__i0__i12__net1 n59__i0__i12__net1 7.75
rk4621 n61__i0__i12__net1 n62__i0__i12__net1 15.125
rk4622 n6__i0__net4 n15__i0__net4 125e-3
rk4623 n8__i0__net4 n16__i0__net4 125e-3
rk4624 n24__pinin n30__pinin 250e-3
rk4625 n26__pinin n31__pinin 22.75
rk4626 n9__i0__net4 n17__i0__net4 250e-3
rk4627 n5__i0__i11__outinv n6__i0__i11__outinv 15.4054
rk4628 n6__i0__i11__outinv n7__i0__i11__outinv 217e-3
rk4629 n7__i0__i11__outinv n8__i0__i11__outinv 15.705
rk4630 n6__i0__i11__outinv n9__i0__i11__outinv 31.537
rk4631 n28__pinin n32__pinin 250e-3
rk4632 n11__i0__net4 n18__i0__net4 250e-3
rk4633 n9__pinout n15__pinout 250e-3
rk4634 i0__i11__outinv n10__i0__i11__outinv 250e-3
rk4635 n11__pinout n16__pinout 250e-3
rk4636 n19__i0__net4 n20__i0__net4 15.7406
rk4637 n20__i0__net4 n21__i0__net4 40.22e-3
rk4638 n21__i0__net4 n22__i0__net4 15.805
rk4639 n20__i0__net4 n23__i0__net4 31.3604
rk4640 n3__i0__i11__outinv n11__i0__i11__outinv 250e-3
rk4641 n13__pinout n17__pinout 250e-3
rk4642 n1737__vddio n1738__vddio 31.2107
rk4643 n1738__vddio n1739__vddio 233.8e-3
rk4644 n1739__vddio n1740__vddio 221.1e-3
rk4645 n1740__vddio n1741__vddio 86.96e-3
rk4646 n1741__vddio n1742__vddio 160.1e-3
rk4647 n1742__vddio n1743__vddio 451.5e-3
rk4648 n1743__vddio n1744__vddio 86.74e-3
rk4649 n1744__vddio n1745__vddio 74.48e-3
rk4650 n1745__vddio n1746__vddio 82.65e-3
rk4651 n1746__vddio n1747__vddio 91.74e-3
rk4652 n1747__vddio n1748__vddio 76.78e-3
rk4653 n1748__vddio n1749__vddio 737e-3
rk4654 n1749__vddio n1750__vddio 73.45e-3
rk4655 n1750__vddio n1751__vddio 166.9e-3
rk4656 n1751__vddio n1752__vddio 178.9e-3
rk4657 n1752__vddio n1753__vddio 141.6e-3
rk4658 n1753__vddio n1754__vddio 232.4e-3
rk4659 n1754__vddio n1755__vddio 88.14e-3
rk4660 n1755__vddio n1702__vddio 285.8e-3
rk4661 n1702__vddio n1394__vddio 1.2847
rk4662 n1739__vddio n1756__vddio 31.1728
rk4663 n1741__vddio n1757__vddio 31.1728
rk4664 n1742__vddio n1758__vddio 31.2108
rk4665 n1743__vddio n1759__vddio 8.02
rk4666 n1744__vddio n1760__vddio 8.0628
rk4667 n1745__vddio n1761__vddio 8.0351
rk4668 n1746__vddio n1762__vddio 8.0209
rk4669 n1747__vddio n1763__vddio 8.0593
rk4670 n1748__vddio n1764__vddio 7.9191
rk4671 n1394__vddio n1738__vddio 18.75
rk4672 n1394__vddio n1740__vddio 3.75
rk4673 n1394__vddio n1744__vddio 2.5
rk4674 n1394__vddio n1747__vddio 1.875
rk4675 n1394__vddio n1749__vddio 2.5
rk4676 n1695__vddio n1750__vddio 9.804e-3
rk4677 n1394__vddio n1751__vddio 1.25
rk4678 n1697__vddio n1752__vddio 8.333e-3
rk4679 n1394__vddio n1753__vddio 1.25
rk4680 n1699__vddio n1754__vddio 8.333e-3
rk4681 n1394__vddio n1755__vddio 1.25
rk4682 n1292__vss n1293__vss 15.599
rk4683 n1293__vss n1294__vss 126e-3
rk4684 n1294__vss n1295__vss 447.7e-3
rk4685 n1295__vss n1296__vss 63.35e-3
rk4686 n1296__vss n1297__vss 158.1e-3
rk4687 n1297__vss n1298__vss 207.1e-3
rk4688 n1298__vss n1299__vss 72.51e-3
rk4689 n1299__vss n1300__vss 75.35e-3
rk4690 n1300__vss n1301__vss 76.27e-3
rk4691 n1301__vss n1302__vss 79.74e-3
rk4692 n1302__vss n1303__vss 83.43e-3
rk4693 n1303__vss n1304__vss 532.4e-3
rk4694 n1304__vss n1305__vss 73.45e-3
rk4695 n1305__vss n1306__vss 166.9e-3
rk4696 n1306__vss n1307__vss 178.9e-3
rk4697 n1307__vss n1308__vss 141.6e-3
rk4698 n1308__vss n1309__vss 232.4e-3
rk4699 n1309__vss n1310__vss 88.14e-3
rk4700 n1310__vss n1311__vss 285.8e-3
rk4701 n1311__vss n573__vss 1.0681
rk4702 n1294__vss n1312__vss 15.4927
rk4703 n1295__vss n1313__vss 15.493
rk4704 n1297__vss n1314__vss 15.4855
rk4705 n1298__vss n1315__vss 15.167
rk4706 n1299__vss n1316__vss 15.1897
rk4707 n1300__vss n1317__vss 15.168
rk4708 n1301__vss n1318__vss 15.1656
rk4709 n1302__vss n1319__vss 15.2065
rk4710 n1303__vss n1320__vss 15.1134
rk4711 n573__vss n1293__vss 6.2
rk4712 n573__vss n1296__vss 3.1
rk4713 n573__vss n1299__vss 2.0667
rk4714 n573__vss n1302__vss 1.55
rk4715 n573__vss n1304__vss 2.0667
rk4716 n1250__vss n1305__vss 9.804e-3
rk4717 n573__vss n1306__vss 1.0333
rk4718 n1252__vss n1307__vss 8.333e-3
rk4719 n573__vss n1308__vss 1.0333
rk4720 n1254__vss n1309__vss 8.333e-3
rk4721 n573__vss n1310__vss 1.0333
rk4722 n1256__vss n1311__vss 8.333e-3
rl1 i0__i14__net1 n2__i0__i14__net1 22.9087
rl2 n3__i0__i14__net1 n4__i0__i14__net1 23.2215
rl3 n5__i0__i14__net1 n6__i0__i14__net1 22.8664
rl4 n7__i0__i14__net1 n8__i0__i14__net1 22.8664
rl5 n9__i0__i14__net1 n10__i0__i14__net1 23.2215
rl6 n11__i0__i14__net1 n12__i0__i14__net1 23.2215
rl7 n13__i0__i14__net1 n14__i0__i14__net1 22.8664
rl8 n15__i0__i14__net1 n16__i0__i14__net1 22.8664
rl9 n17__i0__i14__net1 n18__i0__i14__net1 23.2215
rl10 n19__i0__i14__net1 n20__i0__i14__net1 23.2215
rl11 n21__i0__i14__net1 n22__i0__i14__net1 24.4918
rl12 n23__i0__i14__net1 n24__i0__i14__net1 24.4918
rl13 n25__i0__i14__net1 n26__i0__i14__net1 23.6861
rl14 n27__i0__i14__net1 n28__i0__i14__net1 23.6861
rl15 n29__i0__i14__net1 n30__i0__i14__net1 24.4918
rl16 n31__i0__i14__net1 n32__i0__i14__net1 24.4918
rl17 n33__i0__i14__net1 n34__i0__i14__net1 23.6861
rl18 n35__i0__i14__net1 n36__i0__i14__net1 23.6861
rl19 n37__i0__i14__net1 n38__i0__i14__net1 24.4918
rl20 n39__i0__i14__net1 n40__i0__i14__net1 24.4918
rl21 n41__i0__i14__net1 n42__i0__i14__net1 23.6861
rl22 n43__i0__i14__net1 n44__i0__i14__net1 23.6861
rl23 n45__i0__i14__net1 n46__i0__i14__net1 24.4918
rl24 n47__i0__i14__net1 n48__i0__i14__net1 24.4918
rl25 n49__i0__i14__net1 n50__i0__i14__net1 23.6861
rl26 n51__i0__i14__net1 n52__i0__i14__net1 23.6861
rl27 n53__i0__i14__net1 n54__i0__i14__net1 24.4918
rl28 n55__i0__i14__net1 n56__i0__i14__net1 24.4918
rl29 n57__i0__i14__net1 n58__i0__i14__net1 23.6861
rl30 n59__i0__i14__net1 n60__i0__i14__net1 23.6861
rl31 n65__i0__i14__net1 n66__i0__i14__net1 24.4918
rl32 n67__i0__i14__net1 n68__i0__i14__net1 24.4918
rl33 n77__i0__i14__net1 n78__i0__i14__net1 23.6861
rl34 n79__i0__i14__net1 n80__i0__i14__net1 23.6861
rl35 n81__i0__i14__net1 n82__i0__i14__net1 23.2215
rl36 n83__i0__i14__net1 n84__i0__i14__net1 23.2215
rl37 n93__i0__i14__net1 n94__i0__i14__net1 23.6861
rl38 n95__i0__i14__net1 n96__i0__i14__net1 23.6861
rl39 n97__i0__i14__net1 n98__i0__i14__net1 23.2215
rl40 n99__i0__i14__net1 n100__i0__i14__net1 23.2215
rl41 n109__i0__i14__net1 n110__i0__i14__net1 23.6861
rl42 n111__i0__i14__net1 n112__i0__i14__net1 23.6861
rl43 n113__i0__i14__net1 n114__i0__i14__net1 23.2215
rl44 n115__i0__i14__net1 n116__i0__i14__net1 23.2215
rl45 n125__i0__i14__net1 n126__i0__i14__net1 23.6861
rl46 n127__i0__i14__net1 n128__i0__i14__net1 23.6861
rl47 n129__i0__i14__net1 n130__i0__i14__net1 23.2215
rl48 n131__i0__i14__net1 n132__i0__i14__net1 23.2215
rl49 n141__i0__i14__net1 n142__i0__i14__net1 23.6861
rl50 n143__i0__i14__net1 n144__i0__i14__net1 23.6861
rl51 n145__i0__i14__net1 n146__i0__i14__net1 23.2215
rl52 n147__i0__i14__net1 n148__i0__i14__net1 23.2215
rl53 n157__i0__i14__net1 n158__i0__i14__net1 23.6861
rl54 n159__i0__i14__net1 n160__i0__i14__net1 23.6861
rl55 n161__i0__i14__net1 n162__i0__i14__net1 23.2215
rl56 n163__i0__i14__net1 n164__i0__i14__net1 23.2215
rl57 n173__i0__i14__net1 n174__i0__i14__net1 23.6861
rl58 n175__i0__i14__net1 n176__i0__i14__net1 23.6861
rl59 n177__i0__i14__net1 n178__i0__i14__net1 23.2215
rl60 n179__i0__i14__net1 n180__i0__i14__net1 23.2215
rl61 n189__i0__i14__net1 n190__i0__i14__net1 23.6861
rl62 n191__i0__i14__net1 n192__i0__i14__net1 23.6861
rl63 n197__i0__i14__net1 n198__i0__i14__net1 23.2215
rl64 n199__i0__i14__net1 n200__i0__i14__net1 23.2215
rl65 n205__i0__i14__net1 n206__i0__i14__net1 23.6861
rl66 n207__i0__i14__net1 n208__i0__i14__net1 23.6861
rl67 n209__i0__i14__net1 n210__i0__i14__net1 23.2215
rl68 n211__i0__i14__net1 n212__i0__i14__net1 23.2215
rl69 n221__i0__i14__net1 n222__i0__i14__net1 23.2215
rl70 n223__i0__i14__net1 n224__i0__i14__net1 23.2215
rl71 n225__i0__i14__net1 n226__i0__i14__net1 23.2215
rl72 n227__i0__i14__net1 n228__i0__i14__net1 23.2215
rl73 n237__i0__i14__net1 n238__i0__i14__net1 23.2215
rl74 n239__i0__i14__net1 n240__i0__i14__net1 23.2215
rl75 n241__i0__i14__net1 n242__i0__i14__net1 23.2215
rl76 n243__i0__i14__net1 n244__i0__i14__net1 23.2215
rl77 n253__i0__i14__net1 n254__i0__i14__net1 23.2215
rl78 n255__i0__i14__net1 n256__i0__i14__net1 23.2215
rl79 n257__i0__i14__net1 n258__i0__i14__net1 23.2215
rl80 n259__i0__i14__net1 n260__i0__i14__net1 23.2215
rl81 n269__i0__i14__net1 n270__i0__i14__net1 23.2215
rl82 n271__i0__i14__net1 n272__i0__i14__net1 23.2215
rl83 n277__i0__i14__net1 n278__i0__i14__net1 23.2215
rl84 n279__i0__i14__net1 n280__i0__i14__net1 23.2215
rl85 n285__i0__i14__net1 n286__i0__i14__net1 23.6861
rl86 n287__i0__i14__net1 n288__i0__i14__net1 23.6861
rl87 n293__i0__i14__net1 n294__i0__i14__net1 23.2215
rl88 n295__i0__i14__net1 n296__i0__i14__net1 23.2215
rl89 n297__i0__i14__net1 n298__i0__i14__net1 23.6861
rl90 n299__i0__i14__net1 n300__i0__i14__net1 23.6861
rl91 n309__i0__i14__net1 n310__i0__i14__net1 24.4918
rl92 n311__i0__i14__net1 n312__i0__i14__net1 24.4918
rl93 n313__i0__i14__net1 n314__i0__i14__net1 23.6861
rl94 n315__i0__i14__net1 n316__i0__i14__net1 23.6861
rl95 n325__i0__i14__net1 n326__i0__i14__net1 24.4918
rl96 n327__i0__i14__net1 n328__i0__i14__net1 24.4918
rl97 n329__i0__i14__net1 n330__i0__i14__net1 23.6861
rl98 n331__i0__i14__net1 n332__i0__i14__net1 23.6861
rl99 n341__i0__i14__net1 n342__i0__i14__net1 24.4918
rl100 n343__i0__i14__net1 n344__i0__i14__net1 24.4918
rl101 n345__i0__i14__net1 n346__i0__i14__net1 23.6861
rl102 n347__i0__i14__net1 n348__i0__i14__net1 23.6861
rl103 n357__i0__i14__net1 n358__i0__i14__net1 24.4918
rl104 n359__i0__i14__net1 n360__i0__i14__net1 24.4918
rl105 n361__i0__i14__net1 n362__i0__i14__net1 23.6861
rl106 n363__i0__i14__net1 n364__i0__i14__net1 23.6861
rl107 n373__i0__i14__net1 n374__i0__i14__net1 24.4918
rl108 n375__i0__i14__net1 n376__i0__i14__net1 24.4918
rl109 n377__i0__i14__net1 n378__i0__i14__net1 23.6861
rl110 n379__i0__i14__net1 n380__i0__i14__net1 23.6861
rl111 n389__i0__i14__net1 n390__i0__i14__net1 24.4918
rl112 n391__i0__i14__net1 n392__i0__i14__net1 24.4918
rl113 n393__i0__i14__net1 n394__i0__i14__net1 23.6861
rl114 n395__i0__i14__net1 n396__i0__i14__net1 23.6861
rl115 n405__i0__i14__net1 n406__i0__i14__net1 24.4918
rl116 n407__i0__i14__net1 n408__i0__i14__net1 24.4918
rl117 n409__i0__i14__net1 n410__i0__i14__net1 23.6861
rl118 n411__i0__i14__net1 n412__i0__i14__net1 23.6861
rl119 n421__i0__i14__net1 n422__i0__i14__net1 24.4918
rl120 n423__i0__i14__net1 n424__i0__i14__net1 24.4918
rl121 n429__i0__i14__net1 n430__i0__i14__net1 23.6861
rl122 n431__i0__i14__net1 n432__i0__i14__net1 23.6861
rl123 n433__i0__i14__net1 n434__i0__i14__net1 23.2215
rl124 n435__i0__i14__net1 n436__i0__i14__net1 23.2215
rl125 n445__i0__i14__net1 n446__i0__i14__net1 23.6861
rl126 n447__i0__i14__net1 n448__i0__i14__net1 23.6861
rl127 n449__i0__i14__net1 n450__i0__i14__net1 23.2215
rl128 n451__i0__i14__net1 n452__i0__i14__net1 23.2215
rl129 n1__clk n2__clk 47.923
rl130 n2__clk n3__clk 51.7692
rl131 n4__clk n5__clk 47.923
rl132 n5__clk n6__clk 51.7692
rl133 n461__i0__i14__net1 n462__i0__i14__net1 23.6861
rl134 n463__i0__i14__net1 n464__i0__i14__net1 23.6861
rl135 n465__i0__i14__net1 n466__i0__i14__net1 23.2215
rl136 n467__i0__i14__net1 n468__i0__i14__net1 23.2215
rl137 s n2__s 49.8461
rl138 n2__s n3__s 88.3077
rl139 i3__net9 n2__i3__net9 77.7258
rl140 n2__i3__net9 n3__i3__net9 45
rl141 n2__i3__net9 n4__i3__net9 104.649
rl142 n477__i0__i14__net1 n478__i0__i14__net1 23.6861
rl143 n479__i0__i14__net1 n480__i0__i14__net1 23.6861
rl144 i1__i9__net4 n2__i1__i9__net4 80.3072
rl145 n4__s n5__s 89.9225
rl146 n7__clk n8__clk 86.0764
rl147 i3__net10 n2__i3__net10 87.9995
rl148 n481__i0__i14__net1 n482__i0__i14__net1 23.2215
rl149 n483__i0__i14__net1 n484__i0__i14__net1 23.2215
rl150 n489__i0__i14__net1 n490__i0__i14__net1 23.6861
rl151 n491__i0__i14__net1 n492__i0__i14__net1 23.6861
rl152 n6__s n7__s 89.9225
rl153 n3__i1__i9__net4 n4__i1__i9__net4 80.3072
rl154 i3__i0__net2 n2__i3__i0__net2 77.7258
rl155 n2__i3__i0__net2 n3__i3__i0__net2 45
rl156 n2__i3__i0__net2 n4__i3__i0__net2 104.649
rl157 n497__i0__i14__net1 n498__i0__i14__net1 23.2215
rl158 n499__i0__i14__net1 n500__i0__i14__net1 23.2215
rl159 n505__i0__i14__net1 n506__i0__i14__net1 23.6861
rl160 n507__i0__i14__net1 n508__i0__i14__net1 23.6861
rl161 n3__i3__net10 n4__i3__net10 86.0764
rl162 n9__clk n10__clk 87.9995
rl163 i1__net3 n2__i1__net3 77.7258
rl164 n2__i1__net3 n3__i1__net3 45
rl165 n2__i1__net3 n4__i1__net3 104.649
rl166 n513__i0__i14__net1 n514__i0__i14__net1 23.2215
rl167 n515__i0__i14__net1 n516__i0__i14__net1 23.2215
rl168 n521__i0__i14__net1 n522__i0__i14__net1 23.6861
rl169 n523__i0__i14__net1 n524__i0__i14__net1 23.6861
rl170 i3__net13 n2__i3__net13 47.923
rl171 n2__i3__net13 n3__i3__net13 51.7692
rl172 n11__clk n12__clk 86.0764
rl173 i1__net1 n2__i1__net1 87.9995
rl174 n529__i0__i14__net1 n530__i0__i14__net1 23.2215
rl175 n531__i0__i14__net1 n532__i0__i14__net1 23.2215
rl176 n4__i3__net13 n5__i3__net13 47.923
rl177 n5__i3__net13 n6__i3__net13 51.7692
rl178 n541__i0__i14__net1 n542__i0__i14__net1 23.2215
rl179 n543__i0__i14__net1 n544__i0__i14__net1 23.2215
rl180 i1__i1__net22 n2__i1__i1__net22 77.7258
rl181 n2__i1__i1__net22 n3__i1__i1__net22 45
rl182 n2__i1__i1__net22 n4__i1__i1__net22 104.649
rl183 n545__i0__i14__net1 n546__i0__i14__net1 23.2215
rl184 n547__i0__i14__net1 n548__i0__i14__net1 23.2215
rl185 n3__i1__net1 n4__i1__net1 86.0764
rl186 n13__clk n14__clk 87.9995
rl187 i3__net11 n2__i3__net11 77.7258
rl188 n2__i3__net11 n3__i3__net11 45
rl189 n2__i3__net11 n4__i3__net11 104.649
rl190 n557__i0__i14__net1 n558__i0__i14__net1 23.2215
rl191 n559__i0__i14__net1 n560__i0__i14__net1 23.2215
rl192 n561__i0__i14__net1 n562__i0__i14__net1 23.2215
rl193 n563__i0__i14__net1 n564__i0__i14__net1 23.2215
rl194 n1__reset n2__reset 82.2302
rl195 n7__i3__net13 n8__i3__net13 86.0764
rl196 i3__net12 n2__i3__net12 87.9995
rl197 n573__i0__i14__net1 n574__i0__i14__net1 23.2215
rl198 n575__i0__i14__net1 n576__i0__i14__net1 23.2215
rl199 n577__i0__i14__net1 n578__i0__i14__net1 23.2215
rl200 n579__i0__i14__net1 n580__i0__i14__net1 23.2215
rl201 i3__i1__net2 n2__i3__i1__net2 77.7258
rl202 n2__i3__i1__net2 n3__i3__i1__net2 45
rl203 n2__i3__i1__net2 n4__i3__i1__net2 104.649
rl204 n8__s n9__s 49.8461
rl205 n9__s n10__s 88.3077
rl206 n589__i0__i14__net1 n590__i0__i14__net1 23.2215
rl207 n591__i0__i14__net1 n592__i0__i14__net1 23.2215
rl208 n3__i3__net12 n4__i3__net12 86.0764
rl209 n9__i3__net13 n10__i3__net13 87.9995
rl210 i1__i10__net4 n2__i1__i10__net4 80.3072
rl211 n16__s n17__s 89.9225
rl212 n593__i0__i14__net1 n594__i0__i14__net1 23.2215
rl213 n595__i0__i14__net1 n596__i0__i14__net1 23.2215
rl214 n601__i0__i14__net1 n602__i0__i14__net1 23.2215
rl215 n603__i0__i14__net1 n604__i0__i14__net1 23.2215
rl216 n18__s n19__s 89.9225
rl217 n3__i1__i10__net4 n4__i1__i10__net4 80.3072
rl218 n1__clk4 n2__clk4 47.923
rl219 n2__clk4 n3__clk4 51.7692
rl220 n609__i0__i14__net1 n610__i0__i14__net1 23.2215
rl221 n611__i0__i14__net1 n612__i0__i14__net1 23.2215
rl222 n617__i0__i14__net1 n618__i0__i14__net1 23.2215
rl223 n619__i0__i14__net1 n620__i0__i14__net1 23.2215
rl224 n4__clk4 n5__clk4 75.8027
rl225 n5__clk4 n6__clk4 46.8551
rl226 n5__clk4 n7__clk4 70.0334
rl227 i1__net5 n2__i1__net5 77.7258
rl228 n2__i1__net5 n3__i1__net5 45
rl229 n2__i1__net5 n4__i1__net5 104.649
rl230 n11__i3__net13 n12__i3__net13 155.769
rl231 n12__i3__net13 n13__i3__net13 98.4704
rl232 n625__i0__i14__net1 n626__i0__i14__net1 23.2215
rl233 n627__i0__i14__net1 n628__i0__i14__net1 23.2215
rl234 n633__i0__i14__net1 n634__i0__i14__net1 23.2215
rl235 n635__i0__i14__net1 n636__i0__i14__net1 23.2215
rl236 n24__clk n25__clk 86.0764
rl237 n9__i1__net1 n10__i1__net1 87.9995
rl238 i3__i6__net1 n2__i3__i6__net1 47.923
rl239 n2__i3__i6__net1 n3__i3__i6__net1 51.7692
rl240 n645__i0__i14__net1 n646__i0__i14__net1 23.2215
rl241 n647__i0__i14__net1 n648__i0__i14__net1 23.2215
rl242 i1__i2__net22 n2__i1__i2__net22 77.7258
rl243 n2__i1__i2__net22 n3__i1__i2__net22 45
rl244 n2__i1__i2__net22 n4__i1__i2__net22 104.649
rl245 n653__i0__i14__net1 n654__i0__i14__net1 23.2215
rl246 n655__i0__i14__net1 n656__i0__i14__net1 23.2215
rl247 n657__i0__i14__net1 n658__i0__i14__net1 23.6861
rl248 n659__i0__i14__net1 n660__i0__i14__net1 23.6861
rl249 n14__i1__net1 n15__i1__net1 86.0764
rl250 n29__clk n30__clk 87.9995
rl251 n669__i0__i14__net1 n670__i0__i14__net1 23.2215
rl252 n671__i0__i14__net1 n672__i0__i14__net1 23.2215
rl253 n673__i0__i14__net1 n674__i0__i14__net1 23.6861
rl254 n675__i0__i14__net1 n676__i0__i14__net1 23.6861
rl255 n6__reset n7__reset 82.2302
rl256 n685__i0__i14__net1 n686__i0__i14__net1 23.2215
rl257 n687__i0__i14__net1 n688__i0__i14__net1 23.2215
rl258 n20__s n21__s 49.8461
rl259 n21__s n22__s 88.3077
rl260 n689__i0__i14__net1 n690__i0__i14__net1 23.6861
rl261 n691__i0__i14__net1 n692__i0__i14__net1 23.6861
rl262 n701__i0__i14__net1 n702__i0__i14__net1 23.2215
rl263 n703__i0__i14__net1 n704__i0__i14__net1 23.2215
rl264 i1__i11__net4 n2__i1__i11__net4 80.3072
rl265 n28__s n29__s 89.9225
rl266 n705__i0__i14__net1 n706__i0__i14__net1 23.6861
rl267 n707__i0__i14__net1 n708__i0__i14__net1 23.6861
rl268 n713__i0__i14__net1 n714__i0__i14__net1 23.2215
rl269 n715__i0__i14__net1 n716__i0__i14__net1 23.2215
rl270 n30__s n31__s 89.9225
rl271 n3__i1__i11__net4 n4__i1__i11__net4 80.3072
rl272 i1__net7 n2__i1__net7 77.7258
rl273 n2__i1__net7 n3__i1__net7 45
rl274 n2__i1__net7 n4__i1__net7 104.649
rl275 n31__clk n32__clk 86.0764
rl276 n16__i1__net1 n17__i1__net1 87.9995
rl277 i1__i3__net22 n2__i1__i3__net22 77.7258
rl278 n2__i1__i3__net22 n3__i1__i3__net22 45
rl279 n2__i1__i3__net22 n4__i1__i3__net22 104.649
rl280 n21__i1__net1 n22__i1__net1 86.0764
rl281 n36__clk n37__clk 87.9995
rl282 i0__net2 n2__i0__net2 24.4918
rl283 n3__i0__net2 n4__i0__net2 24.4918
rl284 n5__i0__net2 n6__i0__net2 23.6861
rl285 n7__i0__net2 n8__i0__net2 23.6861
rl286 n11__reset n12__reset 82.2302
rl287 n9__i0__net2 n10__i0__net2 24.4918
rl288 n11__i0__net2 n12__i0__net2 24.4918
rl289 n13__i0__net2 n14__i0__net2 23.6861
rl290 n15__i0__net2 n16__i0__net2 23.6861
rl291 n17__i0__net2 n18__i0__net2 23.2215
rl292 n19__i0__net2 n20__i0__net2 23.2215
rl293 n21__i0__net2 n22__i0__net2 23.6861
rl294 n23__i0__net2 n24__i0__net2 23.6861
rl295 pinin n2__pinin 110.772
rl296 n2__pinin n3__pinin 68.5478
rl297 n3__pinin n4__pinin 72.348
rl298 n4__pinin n5__pinin 75.7689
rl299 n5__pinin n6__pinin 13.7551
rl300 n2__pinin n7__pinin 118.464
rl301 n3__pinin n8__pinin 116.943
rl302 n3__pinin n9__pinin 109.251
rl303 n4__pinin n10__pinin 116.943
rl304 n4__pinin n11__pinin 109.251
rl305 n5__pinin n12__pinin 106.191
rl306 n5__pinin n13__pinin 104.268
rl307 n25__i0__net2 n26__i0__net2 23.2215
rl308 n27__i0__net2 n28__i0__net2 23.2215
rl309 n29__i0__net2 n30__i0__net2 23.6861
rl310 n31__i0__net2 n32__i0__net2 23.6861
rl311 n33__i0__net2 n34__i0__net2 23.2215
rl312 n35__i0__net2 n36__i0__net2 23.2215
rl313 n37__i0__net2 n38__i0__net2 23.6861
rl314 n39__i0__net2 n40__i0__net2 23.6861
rl315 n41__i0__net2 n42__i0__net2 23.2215
rl316 n43__i0__net2 n44__i0__net2 23.2215
rl317 n45__i0__net2 n46__i0__net2 23.6861
rl318 n47__i0__net2 n48__i0__net2 23.6861
rl319 n49__i0__net2 n50__i0__net2 23.2215
rl320 n51__i0__net2 n52__i0__net2 23.2215
rl321 n53__i0__net2 n54__i0__net2 23.6861
rl322 n55__i0__net2 n56__i0__net2 23.6861
rl323 n57__i0__net2 n58__i0__net2 23.2215
rl324 n59__i0__net2 n60__i0__net2 23.2215
rl325 n69__i0__net2 n70__i0__net2 23.6861
rl326 n71__i0__net2 n72__i0__net2 23.6861
rl327 n73__i0__net2 n74__i0__net2 23.2215
rl328 n75__i0__net2 n76__i0__net2 23.2215
rl329 n85__i0__net2 n86__i0__net2 23.6861
rl330 n87__i0__net2 n88__i0__net2 23.6861
rl331 n93__i0__net2 n94__i0__net2 23.2215
rl332 n95__i0__net2 n96__i0__net2 23.2215
rl333 n101__i0__net2 n102__i0__net2 23.6861
rl334 n103__i0__net2 n104__i0__net2 23.6861
rl335 n105__i0__net2 n106__i0__net2 23.2215
rl336 n107__i0__net2 n108__i0__net2 23.2215
rl337 n117__i0__net2 n118__i0__net2 23.2215
rl338 n119__i0__net2 n120__i0__net2 23.2215
rl339 n121__i0__net2 n122__i0__net2 23.2215
rl340 n123__i0__net2 n124__i0__net2 23.2215
rl341 n133__i0__net2 n134__i0__net2 23.2215
rl342 n135__i0__net2 n136__i0__net2 23.2215
rl343 n137__i0__net2 n138__i0__net2 23.2215
rl344 n139__i0__net2 n140__i0__net2 23.2215
rl345 n149__i0__net2 n150__i0__net2 23.2215
rl346 n151__i0__net2 n152__i0__net2 23.2215
rl347 n153__i0__net2 n154__i0__net2 23.2215
rl348 n155__i0__net2 n156__i0__net2 23.2215
rl349 n177__i0__net2 n178__i0__net2 23.2215
rl350 n179__i0__net2 n180__i0__net2 23.2215
rl351 i0__i13__net1 n2__i0__i13__net1 23.2215
rl352 n3__i0__i13__net1 n4__i0__i13__net1 23.2215
rl353 n5__i0__i13__net1 n6__i0__i13__net1 23.2215
rl354 n7__i0__i13__net1 n8__i0__i13__net1 23.6861
rl355 n9__i0__i13__net1 n10__i0__i13__net1 23.2215
rl356 n11__i0__i13__net1 n12__i0__i13__net1 23.2215
rl357 n13__i0__i13__net1 n14__i0__i13__net1 23.2215
rl358 n15__i0__i13__net1 n16__i0__i13__net1 23.6861
rl359 n17__i0__i13__net1 n18__i0__i13__net1 23.2215
rl360 n19__i0__i13__net1 n20__i0__i13__net1 23.2215
rl361 n21__i0__i13__net1 n22__i0__i13__net1 23.6861
rl362 n23__i0__i13__net1 n24__i0__i13__net1 23.6861
rl363 n25__i0__i13__net1 n26__i0__i13__net1 23.2215
rl364 n27__i0__i13__net1 n28__i0__i13__net1 24.4918
rl365 n29__i0__i13__net1 n30__i0__i13__net1 23.6861
rl366 n31__i0__i13__net1 n32__i0__i13__net1 23.6861
rl367 n33__i0__i13__net1 n34__i0__i13__net1 23.2215
rl368 n35__i0__i13__net1 n36__i0__i13__net1 24.4918
rl369 n37__i0__i13__net1 n38__i0__i13__net1 23.6861
rl370 n39__i0__i13__net1 n40__i0__i13__net1 23.6861
rl371 n41__i0__i13__net1 n42__i0__i13__net1 23.2215
rl372 n43__i0__i13__net1 n44__i0__i13__net1 24.4918
rl373 n45__i0__i13__net1 n46__i0__i13__net1 23.6861
rl374 n47__i0__i13__net1 n48__i0__i13__net1 23.6861
rl375 n49__i0__i13__net1 n50__i0__i13__net1 23.2215
rl376 n51__i0__i13__net1 n52__i0__i13__net1 24.4918
rl377 n53__i0__i13__net1 n54__i0__i13__net1 23.6861
rl378 n55__i0__i13__net1 n56__i0__i13__net1 23.6861
rl379 n61__i0__i13__net1 n62__i0__i13__net1 23.2215
rl380 n63__i0__i13__net1 n64__i0__i13__net1 24.4918
rl381 n65__i0__i13__net1 n66__i0__i13__net1 23.6861
rl382 n67__i0__i13__net1 n68__i0__i13__net1 23.6861
rl383 n77__i0__i13__net1 n78__i0__i13__net1 23.2215
rl384 n79__i0__i13__net1 n80__i0__i13__net1 24.4918
rl385 n81__i0__i13__net1 n82__i0__i13__net1 23.6861
rl386 n83__i0__i13__net1 n84__i0__i13__net1 23.6861
rl387 n93__i0__i13__net1 n94__i0__i13__net1 23.2215
rl388 n95__i0__i13__net1 n96__i0__i13__net1 24.4918
rl389 n99__i0__i13__net1 n100__i0__i13__net1 23.6861
rl390 n101__i0__i13__net1 n102__i0__i13__net1 23.6861
rl391 n121__i0__i13__net1 n122__i0__i13__net1 23.2215
rl392 n123__i0__i13__net1 n124__i0__i13__net1 24.4918
rl393 i0__net3 n2__i0__net3 23.6861
rl394 n3__i0__net3 n4__i0__net3 23.6861
rl395 n5__i0__net3 n6__i0__net3 23.6861
rl396 n7__i0__net3 n8__i0__net3 23.6861
rl397 n9__i0__net3 n10__i0__net3 23.2215
rl398 n11__i0__net3 n12__i0__net3 23.2215
rl399 n13__i0__net3 n14__i0__net3 23.6861
rl400 n15__i0__net3 n16__i0__net3 23.6861
rl401 n17__i0__net3 n18__i0__net3 23.2215
rl402 n19__i0__net3 n20__i0__net3 23.2215
rl403 n21__i0__net3 n22__i0__net3 23.6861
rl404 n23__i0__net3 n24__i0__net3 23.6861
rl405 i0__i12__net1 n2__i0__i12__net1 23.6861
rl406 n3__i0__i12__net1 n4__i0__i12__net1 23.6861
rl407 n5__i0__i12__net1 n6__i0__i12__net1 23.6861
rl408 n7__i0__i12__net1 n8__i0__i12__net1 23.6861
rl409 n9__i0__i12__net1 n10__i0__i12__net1 23.6861
rl410 n11__i0__i12__net1 n12__i0__i12__net1 23.6861
rl411 n13__i0__i12__net1 n14__i0__i12__net1 23.6861
rl412 n15__i0__i12__net1 n16__i0__i12__net1 23.6861
rl413 n17__i0__i12__net1 n18__i0__i12__net1 23.6861
rl414 n19__i0__i12__net1 n20__i0__i12__net1 23.6861
rl415 n21__i0__i12__net1 n22__i0__i12__net1 23.6861
rl416 n23__i0__i12__net1 n24__i0__i12__net1 23.6861
rl417 n25__i0__i12__net1 n26__i0__i12__net1 23.6861
rl418 n27__i0__i12__net1 n28__i0__i12__net1 23.6861
rl419 i0__net4 n2__i0__net4 23.6861
rl420 n3__i0__net4 n4__i0__net4 23.6861
rl421 n5__i0__net4 n6__i0__net4 23.6861
rl422 n7__i0__net4 n8__i0__net4 23.6861
rl423 n24__pinin n25__pinin 33.8201
rl424 n26__pinin n27__pinin 9.4696
rl425 n9__i0__net4 n10__i0__net4 36.1001
rl426 n28__pinin n29__pinin 33.8201
rl427 n11__i0__net4 n12__i0__net4 36.1001
rl428 n9__pinout n10__pinout 36.1001
rl429 i0__i11__outinv n2__i0__i11__outinv 34.6001
rl430 n11__pinout n12__pinout 36.1001
rl431 n3__i0__i11__outinv n4__i0__i11__outinv 33.8201
rl432 n13__pinout n14__pinout 36.1001
mi0__i14__m1_96__rcx n45__vddio n24__i0__i14__net1 n119__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_95__rcx n80__chipdriverout n19__i0__i14__net1 n45__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_94__rcx n24__vddio n15__i0__i14__net1 n80__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_93__rcx n41__chipdriverout n11__i0__i14__net1 n24__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_92__rcx n3__vddio n7__i0__i14__net1 n41__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_91__rcx n3__chipdriverout n3__i0__i14__net1 n3__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.44e-12 AS=1.44e-12 PD=19.55e-6 PS=19.55e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_90__rcx n108__vddio n48__i0__i14__net1 n247__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_89__rcx n208__chipdriverout n43__i0__i14__net1 n108__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_88__rcx n87__vddio n40__i0__i14__net1 n208__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_87__rcx n169__chipdriverout n35__i0__i14__net1 n87__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_86__rcx n66__vddio n32__i0__i14__net1 n169__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_85__rcx n119__chipdriverout n27__i0__i14__net1 n66__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_84__rcx n171__vddio n83__i0__i14__net1 n364__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_83__rcx n325__chipdriverout n79__i0__i14__net1 n171__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_82__rcx n150__vddio n68__i0__i14__net1 n325__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_81__rcx n286__chipdriverout n59__i0__i14__net1 n150__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_80__rcx n129__vddio n56__i0__i14__net1 n286__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_79__rcx n247__chipdriverout n51__i0__i14__net1 n129__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_78__rcx n234__vddio n131__i0__i14__net1 n495__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_77__rcx n442__chipdriverout n127__i0__i14__net1 n234__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_76__rcx n213__vddio n115__i0__i14__net1 n442__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_75__rcx n403__chipdriverout n111__i0__i14__net1 n213__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_74__rcx n192__vddio n99__i0__i14__net1 n403__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_73__rcx n364__chipdriverout n95__i0__i14__net1 n192__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_72__rcx n297__vddio n179__i0__i14__net1 n612__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_71__rcx n573__chipdriverout n175__i0__i14__net1 n297__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_70__rcx n276__vddio n163__i0__i14__net1 n573__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_69__rcx n534__chipdriverout n159__i0__i14__net1 n276__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_68__rcx n255__vddio n147__i0__i14__net1 n534__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_67__rcx n495__chipdriverout n143__i0__i14__net1 n255__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_66__rcx n360__vddio n227__i0__i14__net1 n729__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_65__rcx n690__chipdriverout n223__i0__i14__net1 n360__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_64__rcx n339__vddio n211__i0__i14__net1 n690__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_63__rcx n651__chipdriverout n207__i0__i14__net1 n339__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_62__rcx n318__vddio n199__i0__i14__net1 n651__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_61__rcx n612__chipdriverout n191__i0__i14__net1 n318__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_60__rcx n423__vddio n279__i0__i14__net1 n832__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_59__rcx n793__chipdriverout n271__i0__i14__net1 n423__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_58__rcx n402__vddio n259__i0__i14__net1 n793__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_57__rcx n743__chipdriverout n255__i0__i14__net1 n402__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_56__rcx n381__vddio n243__i0__i14__net1 n743__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_55__rcx n729__chipdriverout n239__i0__i14__net1 n381__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_54__rcx n486__vddio n328__i0__i14__net1 n949__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_53__rcx n930__chipdriverout n315__i0__i14__net1 n486__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_52__rcx n465__vddio n312__i0__i14__net1 n930__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_51__rcx n875__chipdriverout n299__i0__i14__net1 n465__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_50__rcx n444__vddio n295__i0__i14__net1 n875__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_49__rcx n832__chipdriverout n287__i0__i14__net1 n444__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_48__rcx n949__chipdriverout n331__i0__i14__net1 n507__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_47__rcx n1066__chipdriverout n379__i0__i14__net1 n583__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_46__rcx n549__vddio n376__i0__i14__net1 n1066__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_45__rcx n1027__chipdriverout n363__i0__i14__net1 n549__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_44__rcx n541__vddio n360__i0__i14__net1 n1027__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_43__rcx n988__chipdriverout n347__i0__i14__net1 n541__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_42__rcx n507__vddio n344__i0__i14__net1 n988__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_41__rcx n1183__chipdriverout n431__i0__i14__net1 n633__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_40__rcx n625__vddio n424__i0__i14__net1 n1183__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_39__rcx n1164__chipdriverout n411__i0__i14__net1 n625__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_38__rcx n591__vddio n408__i0__i14__net1 n1164__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_37__rcx n1125__chipdriverout n395__i0__i14__net1 n591__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_36__rcx n583__vddio n392__i0__i14__net1 n1125__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_35__rcx n1320__chipdriverout n479__i0__i14__net1 n696__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_34__rcx n675__vddio n467__i0__i14__net1 n1320__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_33__rcx n1261__chipdriverout n463__i0__i14__net1 n675__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_32__rcx n667__vddio n451__i0__i14__net1 n1261__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_31__rcx n1222__chipdriverout n447__i0__i14__net1 n667__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_30__rcx n633__vddio n435__i0__i14__net1 n1222__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_29__rcx n1417__chipdriverout n523__i0__i14__net1 n759__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_28__rcx n738__vddio n515__i0__i14__net1 n1417__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_27__rcx n1378__chipdriverout n507__i0__i14__net1 n738__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_26__rcx n717__vddio n499__i0__i14__net1 n1378__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_25__rcx n1339__chipdriverout n491__i0__i14__net1 n717__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_24__rcx n696__vddio n483__i0__i14__net1 n1339__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_23__rcx n1547__chipdriverout n575__i0__i14__net1 n822__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_22__rcx n801__vddio n563__i0__i14__net1 n1547__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_21__rcx n1495__chipdriverout n559__i0__i14__net1 n801__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_20__rcx n780__vddio n547__i0__i14__net1 n1495__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_19__rcx n1456__chipdriverout n543__i0__i14__net1 n780__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_18__rcx n759__vddio n531__i0__i14__net1 n1456__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_17__rcx n1653__chipdriverout n619__i0__i14__net1 n885__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_16__rcx n877__vddio n611__i0__i14__net1 n1653__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_15__rcx n1614__chipdriverout n603__i0__i14__net1 n877__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_14__rcx n843__vddio n595__i0__i14__net1 n1614__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_13__rcx n1586__chipdriverout n591__i0__i14__net1 n843__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_12__rcx n822__vddio n579__i0__i14__net1 n1586__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_11__rcx n1770__chipdriverout n671__i0__i14__net1 n961__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_10__rcx n927__vddio n659__i0__i14__net1 n1770__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_9__rcx n1756__chipdriverout n655__i0__i14__net1 n927__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_8__rcx n906__vddio n647__i0__i14__net1 n1756__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_7__rcx n1692__chipdriverout n635__i0__i14__net1 n906__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_6__rcx n885__vddio n627__i0__i14__net1 n1692__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_5__rcx n990__vddio n707__i0__i14__net1 n1887__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_4__rcx n1848__chipdriverout n703__i0__i14__net1 n990__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_3__rcx n982__vddio n691__i0__i14__net1 n1848__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_2__rcx n1825__chipdriverout n687__i0__i14__net1 n982__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1_1__rcx n961__vddio n675__i0__i14__net1 n1825__chipdriverout n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m1 n1887__chipdriverout n715__i0__i14__net1 n1011__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.55e-6 PS=19.55e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_27__rcx n1144__vddio n27__i0__net2 n908__i0__i14__net1 n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_26__rcx n869__i0__i14__net1 n23__i0__net2 n1144__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_25__rcx n1123__vddio n19__i0__net2 n869__i0__i14__net1 n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_24__rcx n830__i0__i14__net1 n15__i0__net2 n1123__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_23__rcx n1102__vddio n12__i0__net2 n830__i0__i14__net1 n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_22__rcx n791__i0__i14__net1 n7__i0__net2 n1102__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_21__rcx n1081__vddio n4__i0__net2 n791__i0__i14__net1 n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.44e-12 AS=1.44e-12 PD=19.55e-6 PS=19.55e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_20__rcx n1014__i0__i14__net1 n55__i0__net2 n1241__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_19__rcx n1207__vddio n51__i0__net2 n1014__i0__i14__net1 n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_18__rcx n986__i0__i14__net1 n47__i0__net2 n1207__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_17__rcx n1186__vddio n43__i0__net2 n986__i0__i14__net1 n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_16__rcx n947__i0__i14__net1 n39__i0__net2 n1186__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_15__rcx n1165__vddio n35__i0__net2 n947__i0__i14__net1 n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_14__rcx n908__i0__i14__net1 n31__i0__net2 n1165__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_13__rcx n1291__vddio n107__i0__net2 n1170__i0__i14__net1 n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_12__rcx n1142__i0__i14__net1 n103__i0__net2 n1291__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_11__rcx n1270__vddio n95__i0__net2 n1142__i0__i14__net1 n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_10__rcx n1103__i0__i14__net1 n87__i0__net2 n1270__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_9__rcx n1249__vddio n75__i0__net2 n1103__i0__i14__net1 n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_8__rcx n1053__i0__i14__net1 n71__i0__net2 n1249__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_7__rcx n1241__vddio n59__i0__net2 n1053__i0__i14__net1 n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_6__rcx n1298__i0__i14__net1 n179__i0__net2 n1375__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.55e-6 PS=19.55e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_5__rcx n1354__vddio n155__i0__net2 n1298__i0__i14__net1 n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_4__rcx n1259__i0__i14__net1 n151__i0__net2 n1354__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_3__rcx n1333__vddio n139__i0__net2 n1259__i0__i14__net1 n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_2__rcx n1209__i0__i14__net1 n135__i0__net2 n1333__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0_1__rcx n1312__vddio n123__i0__net2 n1209__i0__i14__net1 n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m0 n1170__i0__i14__net1 n119__i0__net2 n1312__vddio n1394__vddio g45p2svt L=150e-9 W=9.6e-6 AD=1.92e-12 AS=1.92e-12 PD=19.6e-6 PS=19.6e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i11__m3_1__rcx n1756__vddio n2__i0__i11__outinv n23__i0__net4 n1394__vddio g45p2svt L=150e-9 W=320e-9 AD=48e-15 AS=48e-15 PD=990e-9 PS=990e-9 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i11__m2_1__rcx n9__i0__i11__outinv n12__i0__net4 n1757__vddio n1394__vddio g45p2svt L=150e-9 W=320e-9 AD=64e-15 AS=64e-15 PD=990e-9 PS=990e-9 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i11__m2 n1758__vddio n10__i0__net4 n9__i0__i11__outinv n1394__vddio g45p2svt L=150e-9 W=320e-9 AD=48e-15 AS=48e-15 PD=990e-9 PS=990e-9 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i11__m3 n23__i0__net4 n4__i0__i11__outinv n1737__vddio n1394__vddio g45p2svt L=150e-9 W=320e-9 AD=64e-15 AS=64e-15 PD=990e-9 PS=990e-9 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_20__rcx n260__i0__net2 n25__i0__i13__net1 n1560__vddio n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_19__rcx n1553__vddio n21__i0__i13__net1 n260__i0__net2 n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_18__rcx n251__i0__net2 n17__i0__i13__net1 n1553__vddio n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_17__rcx n1546__vddio n13__i0__i13__net1 n251__i0__net2 n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_16__rcx n246__i0__net2 n9__i0__i13__net1 n1546__vddio n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_15__rcx n1539__vddio n5__i0__i13__net1 n246__i0__net2 n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_14__rcx n233__i0__net2 i0__i13__net1 n1539__vddio n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=576e-15 AS=576e-15 PD=8.03e-6 PS=8.03e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_13__rcx n1560__vddio n29__i0__i13__net1 n269__i0__net2 n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_12__rcx n296__i0__net2 n61__i0__i13__net1 n1588__vddio n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_11__rcx n1581__vddio n53__i0__i13__net1 n296__i0__net2 n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_10__rcx n287__i0__net2 n49__i0__i13__net1 n1581__vddio n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_9__rcx n1574__vddio n45__i0__i13__net1 n287__i0__net2 n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_8__rcx n278__i0__net2 n41__i0__i13__net1 n1574__vddio n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_7__rcx n1568__vddio n37__i0__i13__net1 n278__i0__net2 n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_6__rcx n269__i0__net2 n33__i0__i13__net1 n1568__vddio n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_5__rcx n327__i0__net2 n121__i0__i13__net1 n1609__vddio n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.03e-6 PS=8.03e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_4__rcx n1602__vddio n99__i0__i13__net1 n327__i0__net2 n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_3__rcx n318__i0__net2 n93__i0__i13__net1 n1602__vddio n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_2__rcx n1595__vddio n81__i0__i13__net1 n318__i0__net2 n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3_1__rcx n305__i0__net2 n77__i0__i13__net1 n1595__vddio n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m3 n1588__vddio n65__i0__i13__net1 n305__i0__net2 n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m2_5__rcx n214__i0__i13__net1 n23__i0__net3 n1638__vddio n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.03e-6 PS=8.03e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m2_4__rcx n1630__vddio n19__i0__net3 n214__i0__i13__net1 n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m2_3__rcx n203__i0__i13__net1 n15__i0__net3 n1630__vddio n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m2_2__rcx n1623__vddio n11__i0__net3 n203__i0__i13__net1 n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m2_1__rcx n192__i0__i13__net1 n7__i0__net3 n1623__vddio n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=768e-15 AS=768e-15 PD=8.08e-6 PS=8.08e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m2 n1617__vddio n3__i0__net3 n192__i0__i13__net1 n1394__vddio g45p2svt L=150e-9 W=3.84e-6 AD=576e-15 AS=576e-15 PD=8.03e-6 PS=8.03e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m1_1__rcx n58__i0__i12__net1 n7__i0__net4 n1759__vddio n1394__vddio g45p2svt L=150e-9 W=960e-9 AD=192e-15 AS=192e-15 PD=2.27e-6 PS=2.27e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m1 n1760__vddio n3__i0__net4 n58__i0__i12__net1 n1394__vddio g45p2svt L=150e-9 W=960e-9 AD=144e-15 AS=144e-15 PD=2.27e-6 PS=2.27e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m0_6__rcx n74__i0__net3 n27__i0__i12__net1 n1761__vddio n1394__vddio g45p2svt L=150e-9 W=960e-9 AD=192e-15 AS=192e-15 PD=2.27e-6 PS=2.27e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m0_5__rcx n1762__vddio n23__i0__i12__net1 n74__i0__net3 n1394__vddio g45p2svt L=150e-9 W=960e-9 AD=192e-15 AS=192e-15 PD=2.32e-6 PS=2.32e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m0_4__rcx n69__i0__net3 n19__i0__i12__net1 n1762__vddio n1394__vddio g45p2svt L=150e-9 W=960e-9 AD=192e-15 AS=192e-15 PD=2.32e-6 PS=2.32e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m0_3__rcx n1763__vddio n15__i0__i12__net1 n69__i0__net3 n1394__vddio g45p2svt L=150e-9 W=960e-9 AD=192e-15 AS=192e-15 PD=2.32e-6 PS=2.32e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m0_2__rcx n62__i0__net3 n11__i0__i12__net1 n1763__vddio n1394__vddio g45p2svt L=150e-9 W=960e-9 AD=192e-15 AS=192e-15 PD=2.32e-6 PS=2.32e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m0_1__rcx n1764__vddio n7__i0__i12__net1 n62__i0__net3 n1394__vddio g45p2svt L=150e-9 W=960e-9 AD=192e-15 AS=192e-15 PD=2.32e-6 PS=2.32e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m0 n52__i0__net3 n3__i0__i12__net1 n1764__vddio n1394__vddio g45p2svt L=150e-9 W=960e-9 AD=144e-15 AS=144e-15 PD=2.27e-6 PS=2.27e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi3__i3__pm0 n8__i3__net11 n1__clk4 n59__vdd n40__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i4__pm0 n5__i3__net12 n4__i3__net13 n51__vdd n40__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i2__pm0 n9__i3__net9 i3__net13 n48__vdd n40__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i5__pm0 n5__i3__net10 n1__clk n39__vdd n40__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i1__pm2 n5__i3__i1__net2 n7__i3__net13 i3__i1__net4 n40__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i1__pm1 n2__i3__i1__net3 i3__i1__net2 n57__vdd n40__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i1__pm0 n8__clk4 n3__i3__net12 i3__i1__net3 n40__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i1__pm3 n2__i3__i1__net4 i3__net11 n54__vdd n40__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i0__pm2 n5__i3__i0__net2 n7__clk i3__i0__net4 n40__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i0__pm1 n2__i3__i0__net3 i3__i0__net2 n46__vdd n40__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i0__pm0 n18__i3__net13 n3__i3__net10 i3__i0__net3 n40__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i0__pm3 n2__i3__i0__net4 i3__net9 n43__vdd n40__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i6__pm2 n35__s i3__i6__net1 n64__vdd n40__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i6__pm0 i3__i6__net2 n4__clk4 n62__vdd n40__vdd g45p1svt L=45e-9 W=480e-9 AD=76.8e-15 AS=76.8e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi3__i6__pm1 n4__i3__i6__net1 n11__i3__net13 i3__i6__net2 n40__vdd g45p1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.26e-6 PS=1.26e-6 NRD=1.16667 NRS=1.16667 M=1
mi2__pm0_3__rcx pinout n9__pinin n5__vdd n6__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=800e-9 PS=800e-9 NRD=1.16667 NRS=1.16667 M=1
mi2__pm0_2__rcx n11__vdd pinin pinout n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi2__pm0_1__rcx n6__pinout n13__pinin n12__vdd n6__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=780e-9 PS=780e-9 NRD=1.16667 NRS=1.16667 M=1
mi2__pm0 n5__vdd n11__pinin n6__pinout n6__vdd g45p1svt L=45e-9 W=240e-9 AD=38.4e-15 AS=38.4e-15 PD=800e-9 PS=800e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i12__pm0 n5__i1__net1 n4__clk n37__vdd n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i3__pm1 n2__i1__i3__net24 i1__i3__net22 n13__vdd n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i3__pm0 n16__pinin n21__i1__net1 i1__i3__net24 n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i3__pm3 n2__i1__i3__net21 i1__net7 n15__vdd n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i3__pm2 n5__i1__i3__net22 n31__clk i1__i3__net21 n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i2__pm1 n2__i1__i2__net24 i1__i2__net22 n21__vdd n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i2__pm0 n3__i1__net6 n14__i1__net1 i1__i2__net24 n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i2__pm3 n2__i1__i2__net21 i1__net5 n23__vdd n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i2__pm2 n5__i1__i2__net22 n24__clk i1__i2__net21 n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i1__pm1 n2__i1__i1__net24 i1__i1__net22 n29__vdd n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i1__pm0 n3__i1__net4 n3__i1__net1 i1__i1__net24 n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i1__pm3 n2__i1__i1__net21 i1__net3 n31__vdd n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i1__pm2 n5__i1__i1__net22 n11__clk i1__i1__net21 n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i11__pm3 n7__i1__i11__net4 n20__s n18__vdd n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i11__pm5 n9__i1__net7 i1__i11__net4 n8__i1__net6 n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i11__pm4 n7__i1__net7 n30__s n1__r0 n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i10__pm3 n7__i1__i10__net4 n8__s n26__vdd n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i10__pm5 n9__i1__net5 i1__i10__net4 n9__i1__net4 n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i10__pm4 n7__i1__net5 n18__s n4__r1 n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i9__pm3 n7__i1__i9__net4 s n34__vdd n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i9__pm5 n9__i1__net3 i1__i9__net4 n3__vdd n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i9__pm4 n7__i1__net3 n6__s n1__r2 n6__vdd g45p1svt L=45e-9 W=240e-9 AD=33.6e-15 AS=33.6e-15 PD=760e-9 PS=760e-9 NRD=1.16667 NRS=1.16667 M=1
mi0__i14__m3_96__rcx n27__vss n22__i0__i14__net1 n133__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_95__rcx n94__chipdriverout n17__i0__i14__net1 n27__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_94__rcx n14__vss n13__i0__i14__net1 n94__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_93__rcx n55__chipdriverout n9__i0__i14__net1 n14__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_92__rcx n1__vss n5__i0__i14__net1 n55__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_91__rcx n16__chipdriverout i0__i14__net1 n1__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=960e-15 AS=960e-15 PD=13.15e-6 PS=13.15e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_90__rcx n66__vss n46__i0__i14__net1 n235__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_89__rcx n196__chipdriverout n41__i0__i14__net1 n66__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_88__rcx n53__vss n38__i0__i14__net1 n196__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_87__rcx n157__chipdriverout n33__i0__i14__net1 n53__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_86__rcx n40__vss n30__i0__i14__net1 n157__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_85__rcx n133__chipdriverout n25__i0__i14__net1 n40__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_84__rcx n105__vss n81__i0__i14__net1 n352__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_83__rcx n313__chipdriverout n77__i0__i14__net1 n105__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_82__rcx n92__vss n66__i0__i14__net1 n313__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_81__rcx n274__chipdriverout n57__i0__i14__net1 n92__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_80__rcx n79__vss n54__i0__i14__net1 n274__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_79__rcx n235__chipdriverout n49__i0__i14__net1 n79__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_78__rcx n144__vss n129__i0__i14__net1 n502__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_77__rcx n430__chipdriverout n125__i0__i14__net1 n144__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_76__rcx n131__vss n113__i0__i14__net1 n430__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_75__rcx n391__chipdriverout n109__i0__i14__net1 n131__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_74__rcx n118__vss n97__i0__i14__net1 n391__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_73__rcx n352__chipdriverout n93__i0__i14__net1 n118__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_72__rcx n183__vss n177__i0__i14__net1 n619__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_71__rcx n580__chipdriverout n173__i0__i14__net1 n183__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_70__rcx n170__vss n161__i0__i14__net1 n580__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_69__rcx n541__chipdriverout n157__i0__i14__net1 n170__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_68__rcx n157__vss n145__i0__i14__net1 n541__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_67__rcx n502__chipdriverout n141__i0__i14__net1 n157__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_66__rcx n222__vss n225__i0__i14__net1 n736__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_65__rcx n697__chipdriverout n221__i0__i14__net1 n222__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_64__rcx n209__vss n209__i0__i14__net1 n697__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_63__rcx n658__chipdriverout n205__i0__i14__net1 n209__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_62__rcx n196__vss n197__i0__i14__net1 n658__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_61__rcx n619__chipdriverout n189__i0__i14__net1 n196__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_60__rcx n269__vss n277__i0__i14__net1 n820__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_59__rcx n781__chipdriverout n269__i0__i14__net1 n269__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_58__rcx n256__vss n257__i0__i14__net1 n781__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_57__rcx n757__chipdriverout n253__i0__i14__net1 n256__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_56__rcx n235__vss n241__i0__i14__net1 n757__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_55__rcx n736__chipdriverout n237__i0__i14__net1 n235__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_54__rcx n308__vss n326__i0__i14__net1 n937__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_53__rcx n924__chipdriverout n313__i0__i14__net1 n308__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_52__rcx n295__vss n310__i0__i14__net1 n924__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_51__rcx n882__chipdriverout n297__i0__i14__net1 n295__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_50__rcx n282__vss n293__i0__i14__net1 n882__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_49__rcx n820__chipdriverout n285__i0__i14__net1 n282__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_48__rcx n937__chipdriverout n329__i0__i14__net1 n321__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_47__rcx n1054__chipdriverout n377__i0__i14__net1 n360__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_46__rcx n339__vss n374__i0__i14__net1 n1054__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_45__rcx n1015__chipdriverout n361__i0__i14__net1 n339__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_44__rcx n334__vss n358__i0__i14__net1 n1015__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_43__rcx n976__chipdriverout n345__i0__i14__net1 n334__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_42__rcx n321__vss n342__i0__i14__net1 n976__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_41__rcx n1171__chipdriverout n429__i0__i14__net1 n391__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_40__rcx n386__vss n422__i0__i14__net1 n1171__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_39__rcx n1158__chipdriverout n409__i0__i14__net1 n386__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_38__rcx n365__vss n406__i0__i14__net1 n1158__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_37__rcx n1119__chipdriverout n393__i0__i14__net1 n365__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_36__rcx n360__vss n390__i0__i14__net1 n1119__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_35__rcx n1314__chipdriverout n477__i0__i14__net1 n440__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_34__rcx n427__vss n465__i0__i14__net1 n1314__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_33__rcx n1249__chipdriverout n461__i0__i14__net1 n427__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_32__rcx n412__vss n449__i0__i14__net1 n1249__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_31__rcx n1210__chipdriverout n445__i0__i14__net1 n412__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_30__rcx n391__vss n433__i0__i14__net1 n1210__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_29__rcx n1405__chipdriverout n521__i0__i14__net1 n471__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_28__rcx n458__vss n513__i0__i14__net1 n1405__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_27__rcx n1366__chipdriverout n505__i0__i14__net1 n458__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_26__rcx n445__vss n497__i0__i14__net1 n1366__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_25__rcx n1327__chipdriverout n489__i0__i14__net1 n445__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_24__rcx n440__vss n481__i0__i14__net1 n1327__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_23__rcx n1535__chipdriverout n573__i0__i14__net1 n510__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_22__rcx n497__vss n561__i0__i14__net1 n1535__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_21__rcx n1483__chipdriverout n557__i0__i14__net1 n497__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_20__rcx n484__vss n545__i0__i14__net1 n1483__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_19__rcx n1444__chipdriverout n541__i0__i14__net1 n484__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_18__rcx n471__vss n529__i0__i14__net1 n1444__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_17__rcx n1667__chipdriverout n617__i0__i14__net1 n549__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_16__rcx n544__vss n609__i0__i14__net1 n1667__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_15__rcx n1628__chipdriverout n601__i0__i14__net1 n544__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_14__rcx n523__vss n593__i0__i14__net1 n1628__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_13__rcx n1574__chipdriverout n589__i0__i14__net1 n523__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_12__rcx n510__vss n577__i0__i14__net1 n1574__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_11__rcx n1784__chipdriverout n669__i0__i14__net1 n638__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_10__rcx n605__vss n657__i0__i14__net1 n1784__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_9__rcx n1763__chipdriverout n653__i0__i14__net1 n605__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_8__rcx n562__vss n645__i0__i14__net1 n1763__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_7__rcx n1706__chipdriverout n633__i0__i14__net1 n562__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_6__rcx n549__vss n625__i0__i14__net1 n1706__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_5__rcx n667__vss n705__i0__i14__net1 n1901__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_4__rcx n1862__chipdriverout n701__i0__i14__net1 n667__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_3__rcx n662__vss n689__i0__i14__net1 n1862__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_2__rcx n1818__chipdriverout n685__i0__i14__net1 n662__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3_1__rcx n638__vss n673__i0__i14__net1 n1818__chipdriverout n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m3 n1901__chipdriverout n713__i0__i14__net1 n680__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.15e-6 PS=13.15e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_27__rcx n819__vss n25__i0__net2 n896__i0__i14__net1 n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_26__rcx n857__i0__i14__net1 n21__i0__net2 n819__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_25__rcx n768__vss n17__i0__net2 n857__i0__i14__net1 n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_24__rcx n818__i0__i14__net1 n13__i0__net2 n768__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_23__rcx n755__vss n10__i0__net2 n818__i0__i14__net1 n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_22__rcx n779__i0__i14__net1 n5__i0__net2 n755__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_21__rcx n742__vss n2__i0__net2 n779__i0__i14__net1 n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=960e-15 AS=960e-15 PD=13.15e-6 PS=13.15e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_20__rcx n1028__i0__i14__net1 n53__i0__net2 n879__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_19__rcx n858__vss n49__i0__net2 n1028__i0__i14__net1 n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_18__rcx n974__i0__i14__net1 n45__i0__net2 n858__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_17__rcx n845__vss n41__i0__net2 n974__i0__i14__net1 n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_16__rcx n935__i0__i14__net1 n37__i0__net2 n845__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_15__rcx n832__vss n33__i0__net2 n935__i0__i14__net1 n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_14__rcx n896__i0__i14__net1 n29__i0__net2 n832__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_13__rcx n910__vss n105__i0__net2 n1184__i0__i14__net1 n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_12__rcx n1130__i0__i14__net1 n101__i0__net2 n910__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_11__rcx n897__vss n93__i0__net2 n1130__i0__i14__net1 n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_10__rcx n1091__i0__i14__net1 n85__i0__net2 n897__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_9__rcx n884__vss n73__i0__net2 n1091__i0__i14__net1 n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_8__rcx n1067__i0__i14__net1 n69__i0__net2 n884__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_7__rcx n879__vss n57__i0__net2 n1067__i0__i14__net1 n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_6__rcx n1286__i0__i14__net1 n177__i0__net2 n962__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.15e-6 PS=13.15e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_5__rcx n949__vss n153__i0__net2 n1286__i0__i14__net1 n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_4__rcx n1247__i0__i14__net1 n149__i0__net2 n949__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_3__rcx n936__vss n137__i0__net2 n1247__i0__i14__net1 n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_2__rcx n1223__i0__i14__net1 n133__i0__net2 n936__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2_1__rcx n923__vss n121__i0__net2 n1223__i0__i14__net1 n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i14__m2 n1184__i0__i14__net1 n117__i0__net2 n923__vss n573__vss g45n2svt L=150e-9 W=6.4e-6 AD=1.28e-12 AS=1.28e-12 PD=13.2e-6 PS=13.2e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i11__m0_2__rcx n22__i0__net4 n10__pinout n1312__vss n573__vss g45n2svt L=150e-9 W=640e-9 AD=96e-15 AS=96e-15 PD=1.63e-6 PS=1.63e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i11__m1_2__rcx n5__i0__i11__outinv n29__pinin n1313__vss n573__vss g45n2svt L=150e-9 W=640e-9 AD=128e-15 AS=128e-15 PD=1.63e-6 PS=1.63e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i11__m1_1__rcx n1314__vss n27__pinin n5__i0__i11__outinv n573__vss g45n2svt L=150e-9 W=640e-9 AD=128e-15 AS=128e-15 PD=1.68e-6 PS=1.68e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i11__m1 n8__i0__i11__outinv n25__pinin n1314__vss n573__vss g45n2svt L=150e-9 W=640e-9 AD=96e-15 AS=96e-15 PD=1.63e-6 PS=1.63e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i11__m0_1__rcx n1312__vss n12__pinout n19__i0__net4 n573__vss g45n2svt L=150e-9 W=640e-9 AD=128e-15 AS=128e-15 PD=1.68e-6 PS=1.68e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i11__m0 n19__i0__net4 n14__pinout n1292__vss n573__vss g45n2svt L=150e-9 W=640e-9 AD=128e-15 AS=128e-15 PD=1.63e-6 PS=1.63e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_20__rcx n263__i0__net2 n28__i0__i13__net1 n1133__vss n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_19__rcx n1128__vss n23__i0__i13__net1 n263__i0__net2 n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_18__rcx n254__i0__net2 n19__i0__i13__net1 n1128__vss n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_17__rcx n1122__vss n15__i0__i13__net1 n254__i0__net2 n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_16__rcx n240__i0__net2 n11__i0__i13__net1 n1122__vss n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_15__rcx n1115__vss n7__i0__i13__net1 n240__i0__net2 n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_14__rcx n236__i0__net2 n3__i0__i13__net1 n1115__vss n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=384e-15 AS=384e-15 PD=5.47e-6 PS=5.47e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_13__rcx n1133__vss n31__i0__i13__net1 n272__i0__net2 n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_12__rcx n299__i0__net2 n64__i0__i13__net1 n1159__vss n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_11__rcx n1153__vss n55__i0__i13__net1 n299__i0__net2 n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_10__rcx n290__i0__net2 n52__i0__i13__net1 n1153__vss n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_9__rcx n1147__vss n47__i0__i13__net1 n290__i0__net2 n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_8__rcx n281__i0__net2 n44__i0__i13__net1 n1147__vss n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_7__rcx n1141__vss n39__i0__i13__net1 n281__i0__net2 n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_6__rcx n272__i0__net2 n36__i0__i13__net1 n1141__vss n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_5__rcx n321__i0__net2 n124__i0__i13__net1 n1179__vss n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.47e-6 PS=5.47e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_4__rcx n1173__vss n101__i0__i13__net1 n321__i0__net2 n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_3__rcx n312__i0__net2 n96__i0__i13__net1 n1173__vss n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_2__rcx n1167__vss n83__i0__i13__net1 n312__i0__net2 n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1_1__rcx n308__i0__net2 n80__i0__i13__net1 n1167__vss n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m1 n1159__vss n67__i0__i13__net1 n308__i0__net2 n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m0_5__rcx n208__i0__i13__net1 n21__i0__net3 n1204__vss n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.47e-6 PS=5.47e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m0_4__rcx n1199__vss n17__i0__net3 n208__i0__i13__net1 n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m0_3__rcx n197__i0__i13__net1 n13__i0__net3 n1199__vss n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m0_2__rcx n1193__vss n9__i0__net3 n197__i0__i13__net1 n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m0_1__rcx n186__i0__i13__net1 n5__i0__net3 n1193__vss n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=512e-15 AS=512e-15 PD=5.52e-6 PS=5.52e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i13__m0 n1185__vss i0__net3 n186__i0__i13__net1 n573__vss g45n2svt L=150e-9 W=2.56e-6 AD=384e-15 AS=384e-15 PD=5.47e-6 PS=5.47e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m2_1__rcx n62__i0__i12__net1 n5__i0__net4 n1315__vss n573__vss g45n2svt L=150e-9 W=640e-9 AD=128e-15 AS=128e-15 PD=1.63e-6 PS=1.63e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m2 n1316__vss i0__net4 n62__i0__i12__net1 n573__vss g45n2svt L=150e-9 W=640e-9 AD=96e-15 AS=96e-15 PD=1.63e-6 PS=1.63e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m3_6__rcx n79__i0__net3 n25__i0__i12__net1 n1317__vss n573__vss g45n2svt L=150e-9 W=640e-9 AD=128e-15 AS=128e-15 PD=1.63e-6 PS=1.63e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m3_5__rcx n1318__vss n21__i0__i12__net1 n79__i0__net3 n573__vss g45n2svt L=150e-9 W=640e-9 AD=128e-15 AS=128e-15 PD=1.68e-6 PS=1.68e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m3_4__rcx n66__i0__net3 n17__i0__i12__net1 n1318__vss n573__vss g45n2svt L=150e-9 W=640e-9 AD=128e-15 AS=128e-15 PD=1.68e-6 PS=1.68e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m3_3__rcx n1319__vss n13__i0__i12__net1 n66__i0__net3 n573__vss g45n2svt L=150e-9 W=640e-9 AD=128e-15 AS=128e-15 PD=1.68e-6 PS=1.68e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m3_2__rcx n59__i0__net3 n9__i0__i12__net1 n1319__vss n573__vss g45n2svt L=150e-9 W=640e-9 AD=128e-15 AS=128e-15 PD=1.68e-6 PS=1.68e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m3_1__rcx n1320__vss n5__i0__i12__net1 n59__i0__net3 n573__vss g45n2svt L=150e-9 W=640e-9 AD=128e-15 AS=128e-15 PD=1.68e-6 PS=1.68e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi0__i12__m3 n50__i0__net3 i0__i12__net1 n1320__vss n573__vss g45n2svt L=150e-9 W=640e-9 AD=96e-15 AS=96e-15 PD=1.63e-6 PS=1.63e-6 NRD=468.75e-3 NRS=468.75e-3 M=1
mi3__i3__nm0 n10__i3__net11 n3__clk4 n594__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i4__nm0 n7__i3__net12 n6__i3__net13 n597__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i2__nm0 n11__i3__net9 n3__i3__net13 n598__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i5__nm0 n7__i3__net10 n3__clk n590__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i1__nm0 n7__i3__i1__net2 i3__net12 i3__i1__net1 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i1__nm3 n2__i3__i1__net5 n4__i3__i1__net2 n595__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i1__nm2 n11__clk4 n9__i3__net13 i3__i1__net5 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i1__nm1 n2__i3__i1__net1 n4__i3__net11 n596__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i0__nm0 n7__i3__i0__net2 i3__net10 i3__i0__net1 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i0__nm3 n2__i3__i0__net5 n4__i3__i0__net2 n599__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i0__nm2 n14__i3__net13 n9__clk i3__i0__net5 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i0__nm1 n2__i3__i0__net1 n4__i3__net9 n600__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i6__nm2 n36__s n3__i3__i6__net1 n591__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i6__nm1 n6__i3__i6__net1 n7__clk4 n593__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi3__i6__nm0 n592__vss n12__i3__net13 n6__i3__i6__net1 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi2__nm0_3__rcx n5__pinout n8__pinin n787__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=560e-9 PS=560e-9 NRD=1.16667 NRS=1.16667 M=1
mi2__nm0_2__rcx n781__vss n7__pinin n5__pinout n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi2__nm0_1__rcx n4__pinout n12__pinin n788__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=540e-9 PS=540e-9 NRD=1.16667 NRS=1.16667 M=1
mi2__nm0 n787__vss n10__pinin n4__pinout n573__vss g45n1svt L=45e-9 W=120e-9 AD=19.2e-15 AS=19.2e-15 PD=560e-9 PS=560e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i12__nm0 n7__i1__net1 n6__clk n807__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i3__nm3 n2__i1__i3__net25 n4__i1__i3__net22 n808__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i3__nm2 n18__pinin n36__clk i1__i3__net25 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i3__nm4 n14__pinin n11__reset n789__vss n573__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.24e-6 PS=1.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi1__i3__nm1 n2__i1__i3__net23 n4__i1__net7 n809__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i3__nm0 n7__i1__i3__net22 n16__i1__net1 i1__i3__net23 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i2__nm3 n2__i1__i2__net25 n4__i1__i2__net22 n812__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i2__nm2 n5__i1__net6 n29__clk i1__i2__net25 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i2__nm4 i1__net6 n6__reset n811__vss n573__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.24e-6 PS=1.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi1__i2__nm1 n2__i1__i2__net23 n4__i1__net5 n813__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i2__nm0 n7__i1__i2__net22 n9__i1__net1 i1__i2__net23 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i1__nm3 n2__i1__i1__net25 n4__i1__i1__net22 n816__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i1__nm2 n5__i1__net4 n13__clk i1__i1__net25 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i1__nm4 i1__net4 n1__reset n815__vss n573__vss g45n1svt L=45e-9 W=480e-9 AD=67.2e-15 AS=67.2e-15 PD=1.24e-6 PS=1.24e-6 NRD=1.16667 NRS=1.16667 M=1
mi1__i1__nm1 n2__i1__i1__net23 n4__i1__net3 n817__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i1__nm0 n7__i1__i1__net22 i1__net1 i1__i1__net23 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i11__nm3 n5__i1__i11__net4 n22__s n810__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i11__nm5 n11__i1__net7 n28__s n10__i1__net6 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i11__nm6 n5__i1__net7 n3__i1__i11__net4 n3__r0 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i10__nm3 n5__i1__i10__net4 n10__s n814__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i10__nm5 n11__i1__net5 n16__s n10__i1__net4 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i10__nm6 n5__i1__net5 n3__i1__i10__net4 n5__r1 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i9__nm3 n5__i1__i9__net4 n3__s n818__vss n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i9__nm5 n11__i1__net3 n4__s n4__vdd n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
mi1__i9__nm6 n5__i1__net3 n3__i1__i9__net4 n3__r2 n573__vss g45n1svt L=45e-9 W=120e-9 AD=16.8e-15 AS=16.8e-15 PD=520e-9 PS=520e-9 NRD=1.16667 NRS=1.16667 M=1
.END
